Pointing Antena                      1    -0.41136D-02  -0.30335D-01  -0.46052D-01  -0.35537D-03   0.36052D-02  -0.40141D-02

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2     0.32807D-01   0.20966D-01  -0.48805D-02
Attitude, Rate, Accelerom Sens       2     0.32807D-01   0.20966D-01  -0.48805D-02
Attitude, Rate, Accelerom Sens       2     0.32807D-01   0.20966D-01  -0.48805D-02
Solar Array Hinge                    4    -0.30801D+00  -0.26367D+00  -0.45888D+00
Solar Array Hinge                    4    -0.30801D+00  -0.26367D+00  -0.45888D+00
Solar Array Hinge                    4    -0.30801D+00  -0.26367D+00  -0.45888D+00

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5     0.45867D-03   0.30879D-01   0.13818D-01  -0.11505D-01  -0.22464D-01   0.17384D-01

MODE# 28/ 34, Frequency (rad/sec), Damping (zeta), Generalized Mass=    64.288       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6    -0.41456D-02   0.17657D-01  -0.57403D-03   0.10431D-02   0.74362D-02  -0.54398D-03
Control Moment Gyros (CMG) Loc       6    -0.41456D-02   0.17657D-01  -0.57403D-03   0.10431D-02   0.74362D-02  -0.54398D-03
Control Moment Gyros (CMG) Loc       6    -0.41456D-02   0.17657D-01  -0.57403D-03   0.10431D-02   0.74362D-02  -0.54398D-03
Control Moment Gyros (CMG) Loc       6    -0.41456D-02   0.17657D-01  -0.57403D-03   0.10431D-02   0.74362D-02  -0.54398D-03

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2    -0.49073D-03   0.78023D-02  -0.12848D-02   0.10431D-02   0.74362D-02  -0.54398D-03
Attitude, Rate, Accelerom Sens       2    -0.49073D-03   0.78023D-02  -0.12848D-02   0.10431D-02   0.74362D-02  -0.54398D-03
Attitude, Rate, Accelerom Sens       2    -0.49073D-03   0.78023D-02  -0.12848D-02   0.10431D-02   0.74362D-02  -0.54398D-03
Attitude, Rate, Accelerom Sens       2    -0.49073D-03   0.78023D-02  -0.12848D-02   0.10431D-02   0.74362D-02  -0.54398D-03
Attitude, Rate, Accelerom Sens       2    -0.49073D-03   0.78023D-02  -0.12848D-02   0.10431D-02   0.74362D-02  -0.54398D-03
Attitude, Rate, Accelerom Sens       2    -0.49073D-03   0.78023D-02  -0.12848D-02   0.10431D-02   0.74362D-02  -0.54398D-03
Pointing Antena                      1    -0.46669D-02  -0.12197D-01   0.25558D-03   0.81860D-03  -0.85252D-04  -0.17945D-02
Pointing Antena                      1    -0.46669D-02  -0.12197D-01   0.25558D-03   0.81860D-03  -0.85252D-04  -0.17945D-02
Pointing Antena                      1    -0.46669D-02  -0.12197D-01   0.25558D-03   0.81860D-03  -0.85252D-04  -0.17945D-02

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2    -0.49073D-03   0.78023D-02  -0.12848D-02
Attitude, Rate, Accelerom Sens       2    -0.49073D-03   0.78023D-02  -0.12848D-02
Attitude, Rate, Accelerom Sens       2    -0.49073D-03   0.78023D-02  -0.12848D-02
Solar Array Hinge                    4    -0.98408D-01   0.95580D+00  -0.67306D-01
Solar Array Hinge                    4    -0.98408D-01   0.95580D+00  -0.67306D-01
Solar Array Hinge                    4    -0.98408D-01   0.95580D+00  -0.67306D-01

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5    -0.25511D-02   0.15769D-01  -0.27077D-03  -0.94966D-02  -0.11238D-01   0.13084D-01

MODE# 29/ 35, Frequency (rad/sec), Damping (zeta), Generalized Mass=    67.674       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6     0.56167D-02  -0.18997D-01   0.14524D+00  -0.48973D-03  -0.10819D-01  -0.10172D-02
Control Moment Gyros (CMG) Loc       6     0.56167D-02  -0.18997D-01   0.14524D+00  -0.48973D-03  -0.10819D-01  -0.10172D-02
Control Moment Gyros (CMG) Loc       6     0.56167D-02  -0.18997D-01   0.14524D+00  -0.48973D-03  -0.10819D-01  -0.10172D-02
Control Moment Gyros (CMG) Loc       6     0.56167D-02  -0.18997D-01   0.14524D+00  -0.48973D-03  -0.10819D-01  -0.10172D-02

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2     0.37666D-01   0.22513D-01  -0.61804D-02  -0.48973D-03  -0.10819D-01  -0.10172D-02
Attitude, Rate, Accelerom Sens       2     0.37666D-01   0.22513D-01  -0.61804D-02  -0.48973D-03  -0.10819D-01  -0.10172D-02
Attitude, Rate, Accelerom Sens       2     0.37666D-01   0.22513D-01  -0.61804D-02  -0.48973D-03  -0.10819D-01  -0.10172D-02
Attitude, Rate, Accelerom Sens       2     0.37666D-01   0.22513D-01  -0.61804D-02  -0.48973D-03  -0.10819D-01  -0.10172D-02
Attitude, Rate, Accelerom Sens       2     0.37666D-01   0.22513D-01  -0.61804D-02  -0.48973D-03  -0.10819D-01  -0.10172D-02
Attitude, Rate, Accelerom Sens       2     0.37666D-01   0.22513D-01  -0.61804D-02  -0.48973D-03  -0.10819D-01  -0.10172D-02
Pointing Antena                      1     0.31400D-02   0.48402D-01  -0.15526D+00   0.13639D-02   0.17869D-01   0.39890D-02
Pointing Antena                      1     0.31400D-02   0.48402D-01  -0.15526D+00   0.13639D-02   0.17869D-01   0.39890D-02
Pointing Antena                      1     0.31400D-02   0.48402D-01  -0.15526D+00   0.13639D-02   0.17869D-01   0.39890D-02

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2     0.37666D-01   0.22513D-01  -0.61804D-02
Attitude, Rate, Accelerom Sens       2     0.37666D-01   0.22513D-01  -0.61804D-02
Attitude, Rate, Accelerom Sens       2     0.37666D-01   0.22513D-01  -0.61804D-02
Solar Array Hinge                    4    -0.31498D-03  -0.22651D-01  -0.19901D-01
Solar Array Hinge                    4    -0.31498D-03  -0.22651D-01  -0.19901D-01
Solar Array Hinge                    4    -0.31498D-03  -0.22651D-01  -0.19901D-01

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5     0.10859D-01   0.21918D-02   0.10192D+00  -0.16525D-01  -0.96872D-02  -0.44964D-01

MODE# 30/ 36, Frequency (rad/sec), Damping (zeta), Generalized Mass=    67.845       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6     0.88304D-02  -0.50752D-02   0.35018D-01  -0.11531D-01  -0.47341D-02  -0.35098D-02
Control Moment Gyros (CMG) Loc       6     0.88304D-02  -0.50752D-02   0.35018D-01  -0.11531D-01  -0.47341D-02  -0.35098D-02
Control Moment Gyros (CMG) Loc       6     0.88304D-02  -0.50752D-02   0.35018D-01  -0.11531D-01  -0.47341D-02  -0.35098D-02
Control Moment Gyros (CMG) Loc       6     0.88304D-02  -0.50752D-02   0.35018D-01  -0.11531D-01  -0.47341D-02  -0.35098D-02

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2     0.31099D-01   0.22383D-01  -0.43666D-02  -0.11531D-01  -0.47341D-02  -0.35098D-02
Attitude, Rate, Accelerom Sens       2     0.31099D-01   0.22383D-01  -0.43666D-02  -0.11531D-01  -0.47341D-02  -0.35098D-02
Attitude, Rate, Accelerom Sens       2     0.31099D-01   0.22383D-01  -0.43666D-02  -0.11531D-01  -0.47341D-02  -0.35098D-02
Attitude, Rate, Accelerom Sens       2     0.31099D-01   0.22383D-01  -0.43666D-02  -0.11531D-01  -0.47341D-02  -0.35098D-02
Attitude, Rate, Accelerom Sens       2     0.31099D-01   0.22383D-01  -0.43666D-02  -0.11531D-01  -0.47341D-02  -0.35098D-02
Attitude, Rate, Accelerom Sens       2     0.31099D-01   0.22383D-01  -0.43666D-02  -0.11531D-01  -0.47341D-02  -0.35098D-02
Pointing Antena                      1     0.42209D-02  -0.11452D+00  -0.37264D-01  -0.19154D-01   0.53005D-02  -0.63307D-02
Pointing Antena                      1     0.42209D-02  -0.11452D+00  -0.37264D-01  -0.19154D-01   0.53005D-02  -0.63307D-02
Pointing Antena                      1     0.42209D-02  -0.11452D+00  -0.37264D-01  -0.19154D-01   0.53005D-02  -0.63307D-02

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2     0.31099D-01   0.22383D-01  -0.43666D-02
Attitude, Rate, Accelerom Sens       2     0.31099D-01   0.22383D-01  -0.43666D-02
Attitude, Rate, Accelerom Sens       2     0.31099D-01   0.22383D-01  -0.43666D-02
Solar Array Hinge                    4     0.40762D-02   0.54721D-03  -0.24497D-01
Solar Array Hinge                    4     0.40762D-02   0.54721D-03  -0.24497D-01
Solar Array Hinge                    4     0.40762D-02   0.54721D-03  -0.24497D-01

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5     0.16327D-01  -0.40181D-02   0.64997D-02   0.10423D+00   0.45042D-01   0.52396D-01

MODE# 31/ 37, Frequency (rad/sec), Damping (zeta), Generalized Mass=    69.880       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6    -0.44732D-02  -0.46279D-01   0.45482D-01  -0.62074D-02   0.46548D-02   0.11577D-01
Control Moment Gyros (CMG) Loc       6    -0.44732D-02  -0.46279D-01   0.45482D-01  -0.62074D-02   0.46548D-02   0.11577D-01
Control Moment Gyros (CMG) Loc       6    -0.44732D-02  -0.46279D-01   0.45482D-01  -0.62074D-02   0.46548D-02   0.11577D-01
Control Moment Gyros (CMG) Loc       6    -0.44732D-02  -0.46279D-01   0.45482D-01  -0.62074D-02   0.46548D-02   0.11577D-01

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2    -0.25372D-01  -0.11489D+00   0.13900D-01  -0.62074D-02   0.46548D-02   0.11577D-01
Attitude, Rate, Accelerom Sens       2    -0.25372D-01  -0.11489D+00   0.13900D-01  -0.62074D-02   0.46548D-02   0.11577D-01
Attitude, Rate, Accelerom Sens       2    -0.25372D-01  -0.11489D+00   0.13900D-01  -0.62074D-02   0.46548D-02   0.11577D-01
Attitude, Rate, Accelerom Sens       2    -0.25372D-01  -0.11489D+00   0.13900D-01  -0.62074D-02   0.46548D-02   0.11577D-01
Attitude, Rate, Accelerom Sens       2    -0.25372D-01  -0.11489D+00   0.13900D-01  -0.62074D-02   0.46548D-02   0.11577D-01
Attitude, Rate, Accelerom Sens       2    -0.25372D-01  -0.11489D+00   0.13900D-01  -0.62074D-02   0.46548D-02   0.11577D-01
Pointing Antena                      1    -0.23681D-02   0.30173D-01   0.21336D-01   0.40898D-02   0.95868D-03   0.43933D-02
Pointing Antena                      1    -0.23681D-02   0.30173D-01   0.21336D-01   0.40898D-02   0.95868D-03   0.43933D-02
Pointing Antena                      1    -0.23681D-02   0.30173D-01   0.21336D-01   0.40898D-02   0.95868D-03   0.43933D-02

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2    -0.25372D-01  -0.11489D+00   0.13900D-01
Attitude, Rate, Accelerom Sens       2    -0.25372D-01  -0.11489D+00   0.13900D-01
Attitude, Rate, Accelerom Sens       2    -0.25372D-01  -0.11489D+00   0.13900D-01
Solar Array Hinge                    4    -0.35374D-02  -0.33171D-02   0.59746D-01
Solar Array Hinge                    4    -0.35374D-02  -0.33171D-02   0.59746D-01
Solar Array Hinge                    4    -0.35374D-02  -0.33171D-02   0.59746D-01

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5    -0.82906D-02  -0.37140D-01   0.25008D-01   0.25522D-01   0.25274D-02  -0.27691D-01

MODE# 32/ 38, Frequency (rad/sec), Damping (zeta), Generalized Mass=    71.349       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6    -0.86033D-02   0.19814D-01   0.13683D+00  -0.13568D-01   0.43212D-02  -0.12660D-01
Control Moment Gyros (CMG) Loc       6    -0.86033D-02   0.19814D-01   0.13683D+00  -0.13568D-01   0.43212D-02  -0.12660D-01
Control Moment Gyros (CMG) Loc       6    -0.86033D-02   0.19814D-01   0.13683D+00  -0.13568D-01   0.43212D-02  -0.12660D-01
Control Moment Gyros (CMG) Loc       6    -0.86033D-02   0.19814D-01   0.13683D+00  -0.13568D-01   0.43212D-02  -0.12660D-01

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2    -0.28270D-01   0.93784D-01   0.20952D-01  -0.13568D-01   0.43212D-02  -0.12660D-01
Attitude, Rate, Accelerom Sens       2    -0.28270D-01   0.93784D-01   0.20952D-01  -0.13568D-01   0.43212D-02  -0.12660D-01
Attitude, Rate, Accelerom Sens       2    -0.28270D-01   0.93784D-01   0.20952D-01  -0.13568D-01   0.43212D-02  -0.12660D-01
Attitude, Rate, Accelerom Sens       2    -0.28270D-01   0.93784D-01   0.20952D-01  -0.13568D-01   0.43212D-02  -0.12660D-01
Attitude, Rate, Accelerom Sens       2    -0.28270D-01   0.93784D-01   0.20952D-01  -0.13568D-01   0.43212D-02  -0.12660D-01
Attitude, Rate, Accelerom Sens       2    -0.28270D-01   0.93784D-01   0.20952D-01  -0.13568D-01   0.43212D-02  -0.12660D-01
Pointing Antena                      1    -0.12431D-01  -0.80720D-01  -0.50551D-01  -0.21344D-01   0.11410D-01  -0.57064D-02
Pointing Antena                      1    -0.12431D-01  -0.80720D-01  -0.50551D-01  -0.21344D-01   0.11410D-01  -0.57064D-02
Pointing Antena                      1    -0.12431D-01  -0.80720D-01  -0.50551D-01  -0.21344D-01   0.11410D-01  -0.57064D-02

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2    -0.28270D-01   0.93784D-01   0.20952D-01
Attitude, Rate, Accelerom Sens       2    -0.28270D-01   0.93784D-01   0.20952D-01
Attitude, Rate, Accelerom Sens       2    -0.28270D-01   0.93784D-01   0.20952D-01
Solar Array Hinge                    4     0.18523D-01   0.29269D-01  -0.36852D-01
Solar Array Hinge                    4     0.18523D-01   0.29269D-01  -0.36852D-01
Solar Array Hinge                    4     0.18523D-01   0.29269D-01  -0.36852D-01

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5    -0.59788D-03   0.22926D-01   0.74172D-01   0.68736D-01  -0.48384D-02  -0.24188D-01

MODE# 33/ 39, Frequency (rad/sec), Damping (zeta), Generalized Mass=    77.348       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6    -0.53166D-01  -0.61414D-01   0.22959D+00  -0.11311D-01  -0.95203D-01   0.22805D-02
Control Moment Gyros (CMG) Loc       6    -0.53166D-01  -0.61414D-01   0.22959D+00  -0.11311D-01  -0.95203D-01   0.22805D-02
Control Moment Gyros (CMG) Loc       6    -0.53166D-01  -0.61414D-01   0.22959D+00  -0.11311D-01  -0.95203D-01   0.22805D-02
Control Moment Gyros (CMG) Loc       6    -0.53166D-01  -0.61414D-01   0.22959D+00  -0.11311D-01  -0.95203D-01   0.22805D-02

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2     0.88878D-01   0.32977D+00  -0.10150D+00  -0.11311D-01  -0.95203D-01   0.22805D-02
Attitude, Rate, Accelerom Sens       2     0.88878D-01   0.32977D+00  -0.10150D+00  -0.11311D-01  -0.95203D-01   0.22805D-02
Attitude, Rate, Accelerom Sens       2     0.88878D-01   0.32977D+00  -0.10150D+00  -0.11311D-01  -0.95203D-01   0.22805D-02
Attitude, Rate, Accelerom Sens       2     0.88878D-01   0.32977D+00  -0.10150D+00  -0.11311D-01  -0.95203D-01   0.22805D-02
Attitude, Rate, Accelerom Sens       2     0.88878D-01   0.32977D+00  -0.10150D+00  -0.11311D-01  -0.95203D-01   0.22805D-02
Attitude, Rate, Accelerom Sens       2     0.88878D-01   0.32977D+00  -0.10150D+00  -0.11311D-01  -0.95203D-01   0.22805D-02
Pointing Antena                      1    -0.57543D-01   0.93275D-01  -0.43553D+00   0.96748D-02   0.39414D-01   0.91428D-02
Pointing Antena                      1    -0.57543D-01   0.93275D-01  -0.43553D+00   0.96748D-02   0.39414D-01   0.91428D-02
Pointing Antena                      1    -0.57543D-01   0.93275D-01  -0.43553D+00   0.96748D-02   0.39414D-01   0.91428D-02

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2     0.88878D-01   0.32977D+00  -0.10150D+00
Attitude, Rate, Accelerom Sens       2     0.88878D-01   0.32977D+00  -0.10150D+00
Attitude, Rate, Accelerom Sens       2     0.88878D-01   0.32977D+00  -0.10150D+00
Solar Array Hinge                    4     0.10840D+00  -0.11458D-01  -0.21205D+00
Solar Array Hinge                    4     0.10840D+00  -0.11458D-01  -0.21205D+00
Solar Array Hinge                    4     0.10840D+00  -0.11458D-01  -0.21205D+00

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5    -0.57220D-01  -0.39803D-01   0.17685D+00  -0.38339D-01  -0.13496D+00  -0.12883D-02

MODE# 34/ 40, Frequency (rad/sec), Damping (zeta), Generalized Mass=    81.514       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6    -0.40973D-01   0.92443D-01   0.17636D+00   0.57188D-01   0.40872D-01   0.95302D-02
Control Moment Gyros (CMG) Loc       6    -0.40973D-01   0.92443D-01   0.17636D+00   0.57188D-01   0.40872D-01   0.95302D-02
Control Moment Gyros (CMG) Loc       6    -0.40973D-01   0.92443D-01   0.17636D+00   0.57188D-01   0.40872D-01   0.95302D-02
Control Moment Gyros (CMG) Loc       6    -0.40973D-01   0.92443D-01   0.17636D+00   0.57188D-01   0.40872D-01   0.95302D-02

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2     0.15680D+00  -0.58893D+00  -0.63254D-01   0.57188D-01   0.40872D-01   0.95302D-02
Attitude, Rate, Accelerom Sens       2     0.15680D+00  -0.58893D+00  -0.63254D-01   0.57188D-01   0.40872D-01   0.95302D-02
Attitude, Rate, Accelerom Sens       2     0.15680D+00  -0.58893D+00  -0.63254D-01   0.57188D-01   0.40872D-01   0.95302D-02
Attitude, Rate, Accelerom Sens       2     0.15680D+00  -0.58893D+00  -0.63254D-01   0.57188D-01   0.40872D-01   0.95302D-02
Attitude, Rate, Accelerom Sens       2     0.15680D+00  -0.58893D+00  -0.63254D-01   0.57188D-01   0.40872D-01   0.95302D-02
Attitude, Rate, Accelerom Sens       2     0.15680D+00  -0.58893D+00  -0.63254D-01   0.57188D-01   0.40872D-01   0.95302D-02
Pointing Antena                      1    -0.45662D-01  -0.14405D-01  -0.30313D+00   0.20770D-01   0.27383D-01  -0.61484D-02
Pointing Antena                      1    -0.45662D-01  -0.14405D-01  -0.30313D+00   0.20770D-01   0.27383D-01  -0.61484D-02
Pointing Antena                      1    -0.45662D-01  -0.14405D-01  -0.30313D+00   0.20770D-01   0.27383D-01  -0.61484D-02

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2     0.15680D+00  -0.58893D+00  -0.63254D-01
Attitude, Rate, Accelerom Sens       2     0.15680D+00  -0.58893D+00  -0.63254D-01
Attitude, Rate, Accelerom Sens       2     0.15680D+00  -0.58893D+00  -0.63254D-01
Solar Array Hinge                    4    -0.32863D+00  -0.27251D-01   0.36377D+00
Solar Array Hinge                    4    -0.32863D+00  -0.27251D-01   0.36377D+00
Solar Array Hinge                    4    -0.32863D+00  -0.27251D-01   0.36377D+00

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5    -0.38638D-01   0.73544D-01   0.15443D+00  -0.85069D-01  -0.12338D+00   0.10222D-01

MODE# 35/ 41, Frequency (rad/sec), Damping (zeta), Generalized Mass=    88.903       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6     0.32130D-03   0.17436D-01   0.52462D-01   0.70554D-01  -0.15311D-02   0.18689D-01
Control Moment Gyros (CMG) Loc       6     0.32130D-03   0.17436D-01   0.52462D-01   0.70554D-01  -0.15311D-02   0.18689D-01
Control Moment Gyros (CMG) Loc       6     0.32130D-03   0.17436D-01   0.52462D-01   0.70554D-01  -0.15311D-02   0.18689D-01
Control Moment Gyros (CMG) Loc       6     0.32130D-03   0.17436D-01   0.52462D-01   0.70554D-01  -0.15311D-02   0.18689D-01

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2    -0.36806D-01  -0.16686D+00   0.20552D-01   0.70554D-01  -0.15311D-02   0.18689D-01
Attitude, Rate, Accelerom Sens       2    -0.36806D-01  -0.16686D+00   0.20552D-01   0.70554D-01  -0.15311D-02   0.18689D-01
Attitude, Rate, Accelerom Sens       2    -0.36806D-01  -0.16686D+00   0.20552D-01   0.70554D-01  -0.15311D-02   0.18689D-01
Attitude, Rate, Accelerom Sens       2    -0.36806D-01  -0.16686D+00   0.20552D-01   0.70554D-01  -0.15311D-02   0.18689D-01
Attitude, Rate, Accelerom Sens       2    -0.36806D-01  -0.16686D+00   0.20552D-01   0.70554D-01  -0.15311D-02   0.18689D-01
Attitude, Rate, Accelerom Sens       2    -0.36806D-01  -0.16686D+00   0.20552D-01   0.70554D-01  -0.15311D-02   0.18689D-01
Pointing Antena                      1     0.94202D-02   0.18918D+00   0.85589D-01   0.71838D-01  -0.49513D-02   0.91369D-02
Pointing Antena                      1     0.94202D-02   0.18918D+00   0.85589D-01   0.71838D-01  -0.49513D-02   0.91369D-02
Pointing Antena                      1     0.94202D-02   0.18918D+00   0.85589D-01   0.71838D-01  -0.49513D-02   0.91369D-02

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2    -0.36806D-01  -0.16686D+00   0.20552D-01
Attitude, Rate, Accelerom Sens       2    -0.36806D-01  -0.16686D+00   0.20552D-01
Attitude, Rate, Accelerom Sens       2    -0.36806D-01  -0.16686D+00   0.20552D-01
Solar Array Hinge                    4     0.35538D-01   0.36599D-02  -0.43541D-01
Solar Array Hinge                    4     0.35538D-01   0.36599D-02  -0.43541D-01
Solar Array Hinge                    4     0.35538D-01   0.36599D-02  -0.43541D-01

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5    -0.13541D-01   0.52026D-02   0.12129D+00  -0.37070D+00   0.44233D-02  -0.49412D-01

MODE# 36/ 42, Frequency (rad/sec), Damping (zeta), Generalized Mass=    90.476       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6    -0.27496D-02   0.13525D-01   0.12398D-01  -0.13709D-01  -0.65213D-02   0.11026D-02
Control Moment Gyros (CMG) Loc       6    -0.27496D-02   0.13525D-01   0.12398D-01  -0.13709D-01  -0.65213D-02   0.11026D-02
Control Moment Gyros (CMG) Loc       6    -0.27496D-02   0.13525D-01   0.12398D-01  -0.13709D-01  -0.65213D-02   0.11026D-02
Control Moment Gyros (CMG) Loc       6    -0.27496D-02   0.13525D-01   0.12398D-01  -0.13709D-01  -0.65213D-02   0.11026D-02

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2     0.23000D-02   0.11690D-01  -0.38556D-02  -0.13709D-01  -0.65213D-02   0.11026D-02
Attitude, Rate, Accelerom Sens       2     0.23000D-02   0.11690D-01  -0.38556D-02  -0.13709D-01  -0.65213D-02   0.11026D-02
Attitude, Rate, Accelerom Sens       2     0.23000D-02   0.11690D-01  -0.38556D-02  -0.13709D-01  -0.65213D-02   0.11026D-02
Attitude, Rate, Accelerom Sens       2     0.23000D-02   0.11690D-01  -0.38556D-02  -0.13709D-01  -0.65213D-02   0.11026D-02
Attitude, Rate, Accelerom Sens       2     0.23000D-02   0.11690D-01  -0.38556D-02  -0.13709D-01  -0.65213D-02   0.11026D-02
Attitude, Rate, Accelerom Sens       2     0.23000D-02   0.11690D-01  -0.38556D-02  -0.13709D-01  -0.65213D-02   0.11026D-02
Pointing Antena                      1    -0.31544D-02  -0.11973D-01  -0.25406D-01   0.10550D-02   0.20897D-02  -0.14281D-02
Pointing Antena                      1    -0.31544D-02  -0.11973D-01  -0.25406D-01   0.10550D-02   0.20897D-02  -0.14281D-02
Pointing Antena                      1    -0.31544D-02  -0.11973D-01  -0.25406D-01   0.10550D-02   0.20897D-02  -0.14281D-02

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2     0.23000D-02   0.11690D-01  -0.38556D-02
Attitude, Rate, Accelerom Sens       2     0.23000D-02   0.11690D-01  -0.38556D-02
Attitude, Rate, Accelerom Sens       2     0.23000D-02   0.11690D-01  -0.38556D-02
Solar Array Hinge                    4    -0.28301D-01  -0.17855D-02  -0.56329D+00
Solar Array Hinge                    4    -0.28301D-01  -0.17855D-02  -0.56329D+00
Solar Array Hinge                    4    -0.28301D-01  -0.17855D-02  -0.56329D+00

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5    -0.15068D-02   0.95596D-02   0.93873D-02   0.31172D-02  -0.11901D-01   0.22662D-02

MODE# 37/ 43, Frequency (rad/sec), Damping (zeta), Generalized Mass=    90.838       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6    -0.35222D-02   0.13842D-01   0.13760D-01  -0.43285D-01  -0.18384D-01   0.32755D-02
Control Moment Gyros (CMG) Loc       6    -0.35222D-02   0.13842D-01   0.13760D-01  -0.43285D-01  -0.18384D-01   0.32755D-02
Control Moment Gyros (CMG) Loc       6    -0.35222D-02   0.13842D-01   0.13760D-01  -0.43285D-01  -0.18384D-01   0.32755D-02
Control Moment Gyros (CMG) Loc       6    -0.35222D-02   0.13842D-01   0.13760D-01  -0.43285D-01  -0.18384D-01   0.32755D-02

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2     0.64156D-02   0.11990D+00  -0.17248D-01  -0.43285D-01  -0.18384D-01   0.32755D-02
Attitude, Rate, Accelerom Sens       2     0.64156D-02   0.11990D+00  -0.17248D-01  -0.43285D-01  -0.18384D-01   0.32755D-02
Attitude, Rate, Accelerom Sens       2     0.64156D-02   0.11990D+00  -0.17248D-01  -0.43285D-01  -0.18384D-01   0.32755D-02
Attitude, Rate, Accelerom Sens       2     0.64156D-02   0.11990D+00  -0.17248D-01  -0.43285D-01  -0.18384D-01   0.32755D-02
Attitude, Rate, Accelerom Sens       2     0.64156D-02   0.11990D+00  -0.17248D-01  -0.43285D-01  -0.18384D-01   0.32755D-02
Attitude, Rate, Accelerom Sens       2     0.64156D-02   0.11990D+00  -0.17248D-01  -0.43285D-01  -0.18384D-01   0.32755D-02
Pointing Antena                      1    -0.43322D-02  -0.17270D-01  -0.39246D-01  -0.43120D-02   0.31762D-02  -0.16543D-02
Pointing Antena                      1    -0.43322D-02  -0.17270D-01  -0.39246D-01  -0.43120D-02   0.31762D-02  -0.16543D-02
Pointing Antena                      1    -0.43322D-02  -0.17270D-01  -0.39246D-01  -0.43120D-02   0.31762D-02  -0.16543D-02

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2     0.64156D-02   0.11990D+00  -0.17248D-01
Attitude, Rate, Accelerom Sens       2     0.64156D-02   0.11990D+00  -0.17248D-01
Attitude, Rate, Accelerom Sens       2     0.64156D-02   0.11990D+00  -0.17248D-01
Solar Array Hinge                    4     0.55231D-01   0.40937D-02   0.70611D-01
Solar Array Hinge                    4     0.55231D-01   0.40937D-02   0.70611D-01
Solar Array Hinge                    4     0.55231D-01   0.40937D-02   0.70611D-01

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5    -0.19320D-02   0.10148D-01   0.38315D-02   0.25973D-02  -0.15704D-01   0.61788D-03

MODE# 38/ 44, Frequency (rad/sec), Damping (zeta), Generalized Mass=    91.568       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6    -0.12098D-01  -0.22146D-01   0.31938D-01   0.48222D-01   0.10971D-01  -0.65713D-02
Control Moment Gyros (CMG) Loc       6    -0.12098D-01  -0.22146D-01   0.31938D-01   0.48222D-01   0.10971D-01  -0.65713D-02
Control Moment Gyros (CMG) Loc       6    -0.12098D-01  -0.22146D-01   0.31938D-01   0.48222D-01   0.10971D-01  -0.65713D-02
Control Moment Gyros (CMG) Loc       6    -0.12098D-01  -0.22146D-01   0.31938D-01   0.48222D-01   0.10971D-01  -0.65713D-02

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2     0.47644D-01  -0.15614D+00  -0.32762D-01   0.48222D-01   0.10971D-01  -0.65713D-02
Attitude, Rate, Accelerom Sens       2     0.47644D-01  -0.15614D+00  -0.32762D-01   0.48222D-01   0.10971D-01  -0.65713D-02
Attitude, Rate, Accelerom Sens       2     0.47644D-01  -0.15614D+00  -0.32762D-01   0.48222D-01   0.10971D-01  -0.65713D-02
Attitude, Rate, Accelerom Sens       2     0.47644D-01  -0.15614D+00  -0.32762D-01   0.48222D-01   0.10971D-01  -0.65713D-02
Attitude, Rate, Accelerom Sens       2     0.47644D-01  -0.15614D+00  -0.32762D-01   0.48222D-01   0.10971D-01  -0.65713D-02
Attitude, Rate, Accelerom Sens       2     0.47644D-01  -0.15614D+00  -0.32762D-01   0.48222D-01   0.10971D-01  -0.65713D-02
Pointing Antena                      1    -0.12275D-01   0.27860D-02  -0.74548D-01  -0.41970D-02   0.61831D-02   0.14525D-02
Pointing Antena                      1    -0.12275D-01   0.27860D-02  -0.74548D-01  -0.41970D-02   0.61831D-02   0.14525D-02
Pointing Antena                      1    -0.12275D-01   0.27860D-02  -0.74548D-01  -0.41970D-02   0.61831D-02   0.14525D-02

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2     0.47644D-01  -0.15614D+00  -0.32762D-01
Attitude, Rate, Accelerom Sens       2     0.47644D-01  -0.15614D+00  -0.32762D-01
Attitude, Rate, Accelerom Sens       2     0.47644D-01  -0.15614D+00  -0.32762D-01
Solar Array Hinge                    4    -0.51777D-01  -0.32967D-02  -0.43816D-01
Solar Array Hinge                    4    -0.51777D-01  -0.32967D-02  -0.43816D-01
Solar Array Hinge                    4    -0.51777D-01  -0.32967D-02  -0.43816D-01

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5    -0.10496D-01  -0.13388D-01   0.13105D-01   0.58243D-01  -0.32658D-01   0.92006D-02

MODE# 39/ 45, Frequency (rad/sec), Damping (zeta), Generalized Mass=    94.234       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6     0.72055D-02   0.62028D-01   0.12967D-01   0.28169D-01  -0.40957D-02   0.79481D-02
Control Moment Gyros (CMG) Loc       6     0.72055D-02   0.62028D-01   0.12967D-01   0.28169D-01  -0.40957D-02   0.79481D-02
Control Moment Gyros (CMG) Loc       6     0.72055D-02   0.62028D-01   0.12967D-01   0.28169D-01  -0.40957D-02   0.79481D-02
Control Moment Gyros (CMG) Loc       6     0.72055D-02   0.62028D-01   0.12967D-01   0.28169D-01  -0.40957D-02   0.79481D-02

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2    -0.34003D-02  -0.10664D+00  -0.29657D-02   0.28169D-01  -0.40957D-02   0.79481D-02
Attitude, Rate, Accelerom Sens       2    -0.34003D-02  -0.10664D+00  -0.29657D-02   0.28169D-01  -0.40957D-02   0.79481D-02
Attitude, Rate, Accelerom Sens       2    -0.34003D-02  -0.10664D+00  -0.29657D-02   0.28169D-01  -0.40957D-02   0.79481D-02
Attitude, Rate, Accelerom Sens       2    -0.34003D-02  -0.10664D+00  -0.29657D-02   0.28169D-01  -0.40957D-02   0.79481D-02
Attitude, Rate, Accelerom Sens       2    -0.34003D-02  -0.10664D+00  -0.29657D-02   0.28169D-01  -0.40957D-02   0.79481D-02
Attitude, Rate, Accelerom Sens       2    -0.34003D-02  -0.10664D+00  -0.29657D-02   0.28169D-01  -0.40957D-02   0.79481D-02
Pointing Antena                      1     0.31007D-02  -0.83403D-01  -0.42046D-02   0.26188D-02   0.30419D-03  -0.71407D-02
Pointing Antena                      1     0.31007D-02  -0.83403D-01  -0.42046D-02   0.26188D-02   0.30419D-03  -0.71407D-02
Pointing Antena                      1     0.31007D-02  -0.83403D-01  -0.42046D-02   0.26188D-02   0.30419D-03  -0.71407D-02

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2    -0.34003D-02  -0.10664D+00  -0.29657D-02
Attitude, Rate, Accelerom Sens       2    -0.34003D-02  -0.10664D+00  -0.29657D-02
Attitude, Rate, Accelerom Sens       2    -0.34003D-02  -0.10664D+00  -0.29657D-02
Solar Array Hinge                    4     0.13988D-01   0.13746D-01  -0.98597D-02
Solar Array Hinge                    4     0.13988D-01   0.13746D-01  -0.98597D-02
Solar Array Hinge                    4     0.13988D-01   0.13746D-01  -0.98597D-02

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5     0.26665D-03   0.47357D-01   0.31109D-01   0.20582D+01   0.19181D+00   0.42481D+00

MODE# 40/ 46, Frequency (rad/sec), Damping (zeta), Generalized Mass=    94.790       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6    -0.11309D-04   0.50357D-02  -0.25109D-02  -0.10151D-01  -0.23728D-02   0.88453D-03
Control Moment Gyros (CMG) Loc       6    -0.11309D-04   0.50357D-02  -0.25109D-02  -0.10151D-01  -0.23728D-02   0.88453D-03
Control Moment Gyros (CMG) Loc       6    -0.11309D-04   0.50357D-02  -0.25109D-02  -0.10151D-01  -0.23728D-02   0.88453D-03
Control Moment Gyros (CMG) Loc       6    -0.11309D-04   0.50357D-02  -0.25109D-02  -0.10151D-01  -0.23728D-02   0.88453D-03

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2    -0.83674D-02   0.35326D-01   0.39820D-02  -0.10151D-01  -0.23728D-02   0.88453D-03
Attitude, Rate, Accelerom Sens       2    -0.83674D-02   0.35326D-01   0.39820D-02  -0.10151D-01  -0.23728D-02   0.88453D-03
Attitude, Rate, Accelerom Sens       2    -0.83674D-02   0.35326D-01   0.39820D-02  -0.10151D-01  -0.23728D-02   0.88453D-03
Attitude, Rate, Accelerom Sens       2    -0.83674D-02   0.35326D-01   0.39820D-02  -0.10151D-01  -0.23728D-02   0.88453D-03
Attitude, Rate, Accelerom Sens       2    -0.83674D-02   0.35326D-01   0.39820D-02  -0.10151D-01  -0.23728D-02   0.88453D-03
Attitude, Rate, Accelerom Sens       2    -0.83674D-02   0.35326D-01   0.39820D-02  -0.10151D-01  -0.23728D-02   0.88453D-03
Pointing Antena                      1    -0.27318D-04  -0.46520D-02   0.77184D-02   0.70009D-03  -0.60550D-03  -0.57922D-03
Pointing Antena                      1    -0.27318D-04  -0.46520D-02   0.77184D-02   0.70009D-03  -0.60550D-03  -0.57922D-03
Pointing Antena                      1    -0.27318D-04  -0.46520D-02   0.77184D-02   0.70009D-03  -0.60550D-03  -0.57922D-03

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2    -0.83674D-02   0.35326D-01   0.39820D-02
Attitude, Rate, Accelerom Sens       2    -0.83674D-02   0.35326D-01   0.39820D-02
Attitude, Rate, Accelerom Sens       2    -0.83674D-02   0.35326D-01   0.39820D-02
Solar Array Hinge                    4    -0.17266D-01   0.55676D+00  -0.33942D-01
Solar Array Hinge                    4    -0.17266D-01   0.55676D+00  -0.33942D-01
Solar Array Hinge                    4    -0.17266D-01   0.55676D+00  -0.33942D-01

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5     0.26096D-03   0.33816D-02  -0.51515D-03  -0.45226D-01  -0.40817D-02  -0.87648D-02
------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
