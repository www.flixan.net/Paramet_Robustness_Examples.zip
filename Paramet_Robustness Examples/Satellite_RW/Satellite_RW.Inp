BATCH MODE INSTRUCTIONS ...............                                                             
Batch for the Flexible Satellite with Reaction Wheels
Flight Vehicle   : Flex Satellite with Reaction Wheels
To Matlab Format : Flex Satellite with Reaction Wheels                                                                                   
---------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Flex Satellite with Reaction Wheels
! This is a simple Satellite model that uses 3 Reaction Wheels, one wheel per axis.
! It contains also 60 flex modes. The modal data are included in bottom of file.
! Title of Parameter Uncertainties data-set is also included for IFL modeling.
! The augmented spacecraft model is used to analyze robustness to structural uncertainties
!
Body Axes Output, Euler Angles
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   50.0         0.0001       0.20896E+08
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   1045.3,      641.02,      505.05,      0.0,        -19.0,       -40.0    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  -0.05,        0.1,         22.625 
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   0.0          29000.0      0.0001       800000.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   0.0          0.0          0.0          0.0    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   0.0          0.0          0.0          0.0    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0000       0.000        0.0000       0.0000,     -0.064744,    0.0000    
External Torque and direction about (x,y,z)                                              :   Torque       0.0          1.0          0.0       
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   0.0          1.0          1.0  
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :   0.0          0.0          0.0         -0.0
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   0.0          0.0          0.0          0.0          0.0          0.0000       0.0000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.0         -0.0          0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:   0.0         -0.0          0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.0         -0.0          0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:   0.0         -0.0          0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0          0.0          0.0000       0.0000       0.0000       0.0000    

Number of Thruster Engines, RCS Jets, No Engine Gimbaling                                :  0

Number of Reaction Wheels                                                                :  3
RW No:  1, Spin Direct. Unit Vect, Init Rot Speed (rpm), Rotor Mom of Inertia (slg-ft^2) :   1.0    0.0    0.0     0.0  0.1   
RW No:  2, Spin Direct. Unit Vect, Init Rot Speed (rpm), Rotor Mom of Inertia (slg-ft^2) :   0.0    1.0    0.0     0.0  0.1
RW No:  3, Spin Direct. Unit Vect, Init Rot Speed (rpm), Rotor Mom of Inertia (slg-ft^2) :   0.0    0.0    1.0     0.0  0.1

Number of Gyros, (Attitude and Rate)                                                     :   6
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 6    :  Roll   Rate           -0.747      0.114    25.572
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 6    :  Pitch  Rate           -0.747      0.114    25.572
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 6    :  Yaw    Rate           -0.747      0.114    25.572
Gyro No  4 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 6    :  Roll   Attitude       -0.747      0.114    25.572
Gyro No  5 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 6    :  Pitch  Attitude       -0.747      0.114    25.572
Gyro No  6 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 6    :  Yaw    Attitude       -0.747      0.114    25.572

Number of Accelerometers, Along Axes: (x,y,z)                                            :  2
Acceleromet No  1 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Loc, Node 7   :  X-axis Accelerat.      0.338      0.648    25.57
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Loc, Node 7   :  Y-axis Accelerat.      0.338      0.648    25.57

Parameter Uncertainties Data
Uncertainties for the Flex Satellite with Reaction Wheels

Number of Bending Modes                                                                  :  60
Flex Satellite with Reaction Wheels (60 Flex Modes)  
---------------------------------------------------------------------------------------------------------------------------------------------
UNCERTAIN PARAMETER VARIATIONS FROM NOMINAL ......                                                                    
Uncertainties for the Flex Satellite with Reaction Wheels
! This is a set of max parameter variations for a Satellite with three Reaction Wheels. The wheel   
! moment of inertia about the rotor, and the spin axis direction are not known very accurately.     
! Also the wheel speed is unknown. There are also uncertainties in the spacecraft moments of        
! inertia, and also in the flex mode frequencies. The damping line is zero and can be omitted.
                                                                                                                                                                                                                            
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :  0.0          0.0          0.0                                                                                           
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :  50.0         30.0         25.0     0.0   0.0    0.0                                                       
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  0.0          0.0          0.0                                                                                                 
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :  0.0          0.0          0.0          0.0                                                                                  
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :  0.0          0.0          0.0          0.0                                                                                    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  0.0          0.0          0.0          0.0                                                                        
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :  0.0          0.0          0.0          0.0   0.0    0.0                                                       
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.0,    0.0,    0.0,   0.0,     0.0,     0.0,    0.0                                                                         
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  0.0,    0.0,    0.0,   0.0,    -0.0,     0.0,    0.0                                                                         
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:  0.0,    0.0,    0.0,   0.0,     0.0,     0.0,    0.0                                            
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:  0.0,    0.0,    0.0,   0.0,    -0.0,     0.0                                                                                 
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  0.0,    0.0,    0.0,   0.0,     0.0,     0.0,    0.0                                                                         
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:  0.0,    0.0,    0.0,   0.0,     0.0,     0.0                                                                                 
                                                                                                                                                                                                                            
Number of Reaction Wheels, (Variations from Nominal Wheel Parameters)                    :  3
RW No:  1, Spin Direct. Unit Vect, Init Rot Speed (rpm), Rotor Mom of Inertia (slg-ft^2) :   0.0    0.1     0.1     10.0    0.02   
RW No:  2, Spin Direct. Unit Vect, Init Rot Speed (rpm), Rotor Mom of Inertia (slg-ft^2) :   0.1    0.0     0.1     10.0    0.02
RW No:  3, Spin Direct. Unit Vect, Init Rot Speed (rpm), Rotor Mom of Inertia (slg-ft^2) :   0.1    0.1     0.0     10.0    0.02

Flex Mode Uncertainties (Mode Number)                                                    :  1     3     4     5     6     42    43    50 
Flex Mode Frequency Variation (additive)                                                 :  0.3   0.4   0.6   2.0   2.0   10.0  10.0  10.0
--------------------------------------------------------------------------------------------------------------------------------------------------------                                                                  
UNCERTAIN PARAMETER VARIATIONS FROM NOMINAL ......
New Uncertainties for Satellite                                                                     
! This is a new set of parameter variations for a Satellite with three Reaction Wheels. The wheel   
! moment of inertia about the rotor, and the spin axis direction are not known very accurately.     
! Also the wheel speed is unknown. There are also uncertainties in the spacecraft moments of        
! inertia, and also in the flex mode frequencies and damping coefficient (zeta).                    
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   0.00000       0.00000       0.00000    
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   50.0000       30.0000       25.0000       0.00000       0.00000       0.00000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   0.00000       0.00000       0.00000    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   0.00000       0.00000       0.00000       0.00000    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   0.00000       0.00000       0.00000       0.00000    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   0.00000       0.00000       0.00000       0.00000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.00000       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   0.00000       0.00000       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.00000       0.00000       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:   0.00000       0.00000       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:   0.00000       0.00000       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.00000       0.00000       0.00000       0.00000       0.00000       0.00000    

Number of Reaction Wheels, (Variations from Nominal Wheel Parameters)                    :  3
RW No:  1, Spin Direct. Unit Vect, Init Rot Speed (rpm), Rotor Mom of Inertia (slg-ft^2) :   0.0    0.1     0.1     10.0    0.02   
RW No:  2, Spin Direct. Unit Vect, Init Rot Speed (rpm), Rotor Mom of Inertia (slg-ft^2) :   0.1    0.0     0.1     10.0    0.02
RW No:  3, Spin Direct. Unit Vect, Init Rot Speed (rpm), Rotor Mom of Inertia (slg-ft^2) :   0.1    0.1     0.0     10.0    0.02
  
Flex Mode Uncertainties (Mode Number)                                                    :      1      3      4      5      6     42     43     50
Flex Mode Frequency (omega) Variation (additive)  (rad/sec)                              :  0.300  0.400  0.600  2.000  2.500 25.000 30.000 40.000
Flex Mode Damping Coefficient (zeta) Variation (additive)                                : 0.0010 0.0000 0.0010 0.0000 0.0010 0.0000 0.0010 0.0010
----------------------------------------------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR : Pre-Selected
Flex Satellite with Reaction Wheels (60 Flex Modes)  
! The flex modes used in this analysis are the same modes that were selected and used in a 
! previous flex spacecraft analysis. We start from Mode #7 because the first 6 rigid-body modes 
! are not included in the modal data because the rigid-body dynamics are included in the vehicle.  
! The Nodes correspond to vehicle locations defined in the vehicle data above.

MODE#  1/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    3.0998       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.20700D+00  -0.43105D-03   0.41763D-01  -0.11013D-02   0.64943D-01  -0.10960D-02
Reaction Wheel #2 CG             58042    -0.20783D+00  -0.16859D-02  -0.31758D-01  -0.11002D-02   0.64942D-01  -0.11005D-02
Reaction Wheel #3 CG             58043    -0.20632D+00  -0.17810D-02  -0.38780D-01  -0.11033D-02   0.64942D-01  -0.10951D-02

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.51466D-01   0.39036D-02   0.38773D-01  -0.11017D-02   0.64943D-01  -0.10969D-02
Inertial Attitude Sensors        31001     0.51466D-01   0.39036D-02   0.38773D-01  -0.11017D-02   0.64943D-01  -0.10969D-02
Inertial Attitude Sensors        31001     0.51466D-01   0.39036D-02   0.38773D-01  -0.11017D-02   0.64943D-01  -0.10969D-02
Inertial Attitude Sensors        31001     0.51466D-01   0.39036D-02   0.38773D-01  -0.11017D-02   0.64943D-01  -0.10969D-02
Inertial Attitude Sensors        31001     0.51466D-01   0.39036D-02   0.38773D-01  -0.11017D-02   0.64943D-01  -0.10969D-02
Inertial Attitude Sensors        31001     0.51466D-01   0.39036D-02   0.38773D-01  -0.11017D-02   0.64943D-01  -0.10969D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.51889D-01   0.27108D-02  -0.32279D-01
Accelerometers                   31002     0.51889D-01   0.27108D-02  -0.32279D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.19474D+00   0.14764D-02   0.14237D+00  -0.11013D-02   0.64937D-01  -0.10964D-02

MODE#  2/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    3.5411       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.16055D-01   0.11559D-02   0.12312D+00  -0.43027D-03   0.61312D-02  -0.22522D-02
Reaction Wheel #2 CG             58042    -0.17762D-01  -0.14244D-02   0.11643D+00  -0.43302D-03   0.61271D-02  -0.22524D-02
Reaction Wheel #3 CG             58043    -0.14674D-01  -0.16130D-02   0.11532D+00  -0.42835D-03   0.61268D-02  -0.22524D-02

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.84765D-02   0.27680D-02   0.12282D+00  -0.43052D-03   0.61282D-02  -0.22528D-02
Inertial Attitude Sensors        31001     0.84765D-02   0.27680D-02   0.12282D+00  -0.43052D-03   0.61282D-02  -0.22528D-02
Inertial Attitude Sensors        31001     0.84765D-02   0.27680D-02   0.12282D+00  -0.43052D-03   0.61282D-02  -0.22528D-02
Inertial Attitude Sensors        31001     0.84765D-02   0.27680D-02   0.12282D+00  -0.43052D-03   0.61282D-02  -0.22528D-02
Inertial Attitude Sensors        31001     0.84765D-02   0.27680D-02   0.12282D+00  -0.43052D-03   0.61282D-02  -0.22528D-02
Inertial Attitude Sensors        31001     0.84765D-02   0.27680D-02   0.12282D+00  -0.43052D-03   0.61282D-02  -0.22528D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.96649D-02   0.32260D-03   0.11594D+00
Accelerometers                   31002     0.96649D-02   0.32260D-03   0.11594D+00

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.15002D-01   0.47249D-02   0.13263D+00  -0.42980D-03   0.61273D-02  -0.22510D-02

MODE#  3/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    4.0845       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.44284D-02   0.85313D-01   0.65868D-02   0.86126D-01   0.10264D-02   0.14099D-01
Reaction Wheel #2 CG             58042     0.62711D-02   0.10146D+00  -0.59962D-01   0.86130D-01   0.10281D-02   0.14099D-01
Reaction Wheel #3 CG             58043    -0.13055D-01   0.10265D+00   0.58039D-01   0.86129D-01   0.10235D-02   0.14100D-01

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001    -0.12631D-02  -0.25675D+00   0.12154D-01   0.86131D-01   0.10263D-02   0.14100D-01
Inertial Attitude Sensors        31001    -0.12631D-02  -0.25675D+00   0.12154D-01   0.86131D-01   0.10263D-02   0.14100D-01
Inertial Attitude Sensors        31001    -0.12631D-02  -0.25675D+00   0.12154D-01   0.86131D-01   0.10263D-02   0.14100D-01
Inertial Attitude Sensors        31001    -0.12631D-02  -0.25675D+00   0.12154D-01   0.86131D-01   0.10263D-02   0.14100D-01
Inertial Attitude Sensors        31001    -0.12631D-02  -0.25675D+00   0.12154D-01   0.86131D-01   0.10263D-02   0.14100D-01
Inertial Attitude Sensors        31001    -0.12631D-02  -0.25675D+00   0.12154D-01   0.86131D-01   0.10263D-02   0.14100D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.87972D-02  -0.24124D+00   0.57048D-01
Accelerometers                   31002    -0.87972D-02  -0.24124D+00   0.57048D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.35434D-02   0.47146D-01   0.39557D-02   0.86141D-01   0.10254D-02   0.14126D-01

MODE#  4/ 10, Frequency (rad/sec), Damping (zeta), Generalized Mass=    6.2672       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.32170D-01  -0.24993D+00   0.23797D-02  -0.10256D-01   0.29845D-02   0.32126D+00
Reaction Wheel #2 CG             58042     0.21166D+00   0.11787D+00   0.67599D-02  -0.10283D-01   0.30016D-02   0.32126D+00
Reaction Wheel #3 CG             58043    -0.22877D+00   0.14513D+00  -0.75771D-02  -0.10283D-01   0.29647D-02   0.32126D+00

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001    -0.41236D-01  -0.19467D+00   0.15745D-02  -0.10273D-01   0.29850D-02   0.32131D+00
Inertial Attitude Sensors        31001    -0.41236D-01  -0.19467D+00   0.15745D-02  -0.10273D-01   0.29850D-02   0.32131D+00
Inertial Attitude Sensors        31001    -0.41236D-01  -0.19467D+00   0.15745D-02  -0.10273D-01   0.29850D-02   0.32131D+00
Inertial Attitude Sensors        31001    -0.41236D-01  -0.19467D+00   0.15745D-02  -0.10273D-01   0.29850D-02   0.32131D+00
Inertial Attitude Sensors        31001    -0.41236D-01  -0.19467D+00   0.15745D-02  -0.10273D-01   0.29850D-02   0.32131D+00
Inertial Attitude Sensors        31001    -0.41236D-01  -0.19467D+00   0.15745D-02  -0.10273D-01   0.29850D-02   0.32131D+00

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.21288D+00   0.15392D+00  -0.71526D-02
Accelerometers                   31002    -0.21288D+00   0.15392D+00  -0.71526D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.15866D-01  -0.74543D+00   0.74976D-02  -0.10204D-01   0.29785D-02   0.32124D+00

MODE#  5/ 11, Frequency (rad/sec), Damping (zeta), Generalized Mass=    25.288       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.46080D-02  -0.55362D-01   0.10013D-03  -0.19522D-02   0.15138D-03   0.70452D-01
Reaction Wheel #2 CG             58042     0.48816D-01   0.25193D-01   0.14553D-02  -0.20471D-02   0.21338D-03   0.70475D-01
Reaction Wheel #3 CG             58043    -0.47660D-01   0.31177D-01  -0.13128D-02  -0.20461D-02   0.81934D-04   0.70471D-01

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001    -0.86042D-02  -0.44368D-01  -0.42424D-04  -0.20131D-02   0.15306D-03   0.70624D-01
Inertial Attitude Sensors        31001    -0.86042D-02  -0.44368D-01  -0.42424D-04  -0.20131D-02   0.15306D-03   0.70624D-01
Inertial Attitude Sensors        31001    -0.86042D-02  -0.44368D-01  -0.42424D-04  -0.20131D-02   0.15306D-03   0.70624D-01
Inertial Attitude Sensors        31001    -0.86042D-02  -0.44368D-01  -0.42424D-04  -0.20131D-02   0.15306D-03   0.70624D-01
Inertial Attitude Sensors        31001    -0.86042D-02  -0.44368D-01  -0.42424D-04  -0.20131D-02   0.15306D-03   0.70624D-01
Inertial Attitude Sensors        31001    -0.86042D-02  -0.44368D-01  -0.42424D-04  -0.20131D-02   0.15306D-03   0.70624D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.46334D-01   0.32256D-01  -0.12864D-02
Accelerometers                   31002    -0.46334D-01   0.32256D-01  -0.12864D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.11335D-02  -0.16463D+00   0.41312D-03  -0.12286D-02   0.13487D-03   0.71660D-01

MODE#  6/ 12, Frequency (rad/sec), Damping (zeta), Generalized Mass=    25.559       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.98298D-01   0.36215D-03  -0.21357D-01   0.24293D-03  -0.28932D-01   0.53131D-03
Reaction Wheel #2 CG             58042     0.98696D-01   0.97114D-03   0.11629D-01   0.21346D-03  -0.28867D-01   0.67188D-03
Reaction Wheel #3 CG             58043     0.97907D-01   0.10795D-02   0.14438D-01   0.30145D-03  -0.28884D-01   0.49955D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001    -0.16866D-01  -0.65533D-03  -0.20000D-01   0.25626D-03  -0.28925D-01   0.56249D-03
Inertial Attitude Sensors        31001    -0.16866D-01  -0.65533D-03  -0.20000D-01   0.25626D-03  -0.28925D-01   0.56249D-03
Inertial Attitude Sensors        31001    -0.16866D-01  -0.65533D-03  -0.20000D-01   0.25626D-03  -0.28925D-01   0.56249D-03
Inertial Attitude Sensors        31001    -0.16866D-01  -0.65533D-03  -0.20000D-01   0.25626D-03  -0.28925D-01   0.56249D-03
Inertial Attitude Sensors        31001    -0.16866D-01  -0.65533D-03  -0.20000D-01   0.25626D-03  -0.28925D-01   0.56249D-03
Inertial Attitude Sensors        31001    -0.16866D-01  -0.65533D-03  -0.20000D-01   0.25626D-03  -0.28925D-01   0.56249D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.17098D-01  -0.44146D-04   0.11525D-01
Accelerometers                   31002    -0.17098D-01  -0.44146D-04   0.11525D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.92830D-01  -0.56110D-03  -0.65975D-01   0.24964D-03  -0.28802D-01   0.54454D-03

MODE#  7/ 13, Frequency (rad/sec), Damping (zeta), Generalized Mass=    26.219       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.89519D-02  -0.80893D-03  -0.18316D-02  -0.28091D-02  -0.23354D-02  -0.99829D-02
Reaction Wheel #2 CG             58042     0.13739D-02  -0.12243D-01   0.29818D-02  -0.28109D-02  -0.23384D-02  -0.99868D-02
Reaction Wheel #3 CG             58043     0.15053D-01  -0.13086D-01  -0.67873D-03  -0.28015D-02  -0.23184D-02  -0.10005D-01

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.31441D-03   0.99890D-02  -0.19065D-02  -0.28150D-02  -0.23342D-02  -0.10004D-01
Inertial Attitude Sensors        31001     0.31441D-03   0.99890D-02  -0.19065D-02  -0.28150D-02  -0.23342D-02  -0.10004D-01
Inertial Attitude Sensors        31001     0.31441D-03   0.99890D-02  -0.19065D-02  -0.28150D-02  -0.23342D-02  -0.10004D-01
Inertial Attitude Sensors        31001     0.31441D-03   0.99890D-02  -0.19065D-02  -0.28150D-02  -0.23342D-02  -0.10004D-01
Inertial Attitude Sensors        31001     0.31441D-03   0.99890D-02  -0.19065D-02  -0.28150D-02  -0.23342D-02  -0.10004D-01
Inertial Attitude Sensors        31001     0.31441D-03   0.99890D-02  -0.19065D-02  -0.28150D-02  -0.23342D-02  -0.10004D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.56641D-02  -0.87357D-03  -0.87643D-03
Accelerometers                   31002     0.56641D-02  -0.87357D-03  -0.87643D-03

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.80206D-02   0.15227D-01  -0.52894D-02  -0.28777D-02  -0.23194D-02  -0.99806D-02

MODE#  8/ 14, Frequency (rad/sec), Damping (zeta), Generalized Mass=    27.119       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.48516D-01   0.20546D-02   0.21787D-01   0.11673D-03   0.24078D-01  -0.24232D-02
Reaction Wheel #2 CG             58042    -0.50335D-01  -0.71844D-03  -0.58769D-02   0.13861D-03   0.24016D-01  -0.24983D-02
Reaction Wheel #3 CG             58043    -0.46979D-01  -0.96054D-03  -0.77684D-02   0.80951D-04   0.24030D-01  -0.24136D-02

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.47525D-01   0.15110D-02   0.20689D-01   0.11501D-03   0.24056D-01  -0.24422D-02
Inertial Attitude Sensors        31001     0.47525D-01   0.15110D-02   0.20689D-01   0.11501D-03   0.24056D-01  -0.24422D-02
Inertial Attitude Sensors        31001     0.47525D-01   0.15110D-02   0.20689D-01   0.11501D-03   0.24056D-01  -0.24422D-02
Inertial Attitude Sensors        31001     0.47525D-01   0.15110D-02   0.20689D-01   0.11501D-03   0.24056D-01  -0.24422D-02
Inertial Attitude Sensors        31001     0.47525D-01   0.15110D-02   0.20689D-01   0.11501D-03   0.24056D-01  -0.24422D-02
Inertial Attitude Sensors        31001     0.47525D-01   0.15110D-02   0.20689D-01   0.11501D-03   0.24056D-01  -0.24422D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.48777D-01  -0.11389D-02  -0.53552D-02
Accelerometers                   31002     0.48777D-01  -0.11389D-02  -0.53552D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.44043D-01   0.58421D-02   0.58876D-01   0.84800D-04   0.24044D-01  -0.24991D-02

MODE#  9/ 15, Frequency (rad/sec), Damping (zeta), Generalized Mass=    88.715       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.22416D-02   0.55112D-01   0.73581D-03   0.21901D-01  -0.15918D-03   0.34348D-01
Reaction Wheel #2 CG             58042     0.24143D-01   0.95439D-01  -0.16302D-01   0.22074D-01   0.54644D-03   0.36090D-01
Reaction Wheel #3 CG             58043    -0.23369D-01   0.98598D-01   0.15123D-01   0.21912D-01  -0.12389D-02   0.36518D-01

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001    -0.54354D-02  -0.32732D-01   0.22583D-02   0.22572D-01  -0.17965D-03   0.36692D-01
Inertial Attitude Sensors        31001    -0.54354D-02  -0.32732D-01   0.22583D-02   0.22572D-01  -0.17965D-03   0.36692D-01
Inertial Attitude Sensors        31001    -0.54354D-02  -0.32732D-01   0.22583D-02   0.22572D-01  -0.17965D-03   0.36692D-01
Inertial Attitude Sensors        31001    -0.54354D-02  -0.32732D-01   0.22583D-02   0.22572D-01  -0.17965D-03   0.36692D-01
Inertial Attitude Sensors        31001    -0.54354D-02  -0.32732D-01   0.22583D-02   0.22572D-01  -0.17965D-03   0.36692D-01
Inertial Attitude Sensors        31001    -0.54354D-02  -0.32732D-01   0.22583D-02   0.22572D-01  -0.17965D-03   0.36692D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.25054D-01   0.72141D-02   0.14411D-01
Accelerometers                   31002    -0.25054D-01   0.72141D-02   0.14411D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.67963D-03  -0.27562D-02  -0.79272D-03   0.21733D-01  -0.43284D-03   0.33920D-01

MODE# 10/ 16, Frequency (rad/sec), Damping (zeta), Generalized Mass=    89.868       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.20961D-02  -0.10114D+00  -0.19367D-02  -0.17227D-01  -0.52034D-03   0.43510D-01
Reaction Wheel #2 CG             58042     0.29986D-01  -0.53534D-01   0.12807D-01  -0.18540D-01  -0.28504D-03   0.42289D-01
Reaction Wheel #3 CG             58043    -0.27785D-01  -0.49983D-01  -0.12921D-01  -0.18398D-01  -0.46790D-03   0.41876D-01

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001    -0.67789D-02  -0.28561D-01  -0.32061D-02  -0.18511D-01  -0.45065D-03   0.43823D-01
Inertial Attitude Sensors        31001    -0.67789D-02  -0.28561D-01  -0.32061D-02  -0.18511D-01  -0.45065D-03   0.43823D-01
Inertial Attitude Sensors        31001    -0.67789D-02  -0.28561D-01  -0.32061D-02  -0.18511D-01  -0.45065D-03   0.43823D-01
Inertial Attitude Sensors        31001    -0.67789D-02  -0.28561D-01  -0.32061D-02  -0.18511D-01  -0.45065D-03   0.43823D-01
Inertial Attitude Sensors        31001    -0.67789D-02  -0.28561D-01  -0.32061D-02  -0.18511D-01  -0.45065D-03   0.43823D-01
Inertial Attitude Sensors        31001    -0.67789D-02  -0.28561D-01  -0.32061D-02  -0.18511D-01  -0.45065D-03   0.43823D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.30232D-01   0.18919D-01  -0.12567D-01
Accelerometers                   31002    -0.30232D-01   0.18919D-01  -0.12567D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.90937D-04  -0.17264D+00  -0.18739D-02  -0.68495D-02  -0.51857D-03   0.60834D-01

MODE# 11/ 17, Frequency (rad/sec), Damping (zeta), Generalized Mass=    91.715       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.13213D+00   0.58175D-03  -0.29885D-01  -0.11681D-04  -0.41525D-01   0.18125D-03
Reaction Wheel #2 CG             58042     0.13219D+00   0.78855D-03   0.18459D-01  -0.58396D-03  -0.40364D-01   0.26665D-02
Reaction Wheel #3 CG             58043     0.13085D+00   0.19458D-02   0.22314D-01   0.10526D-02  -0.40688D-01  -0.34390D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001    -0.33803D-01  -0.55121D-03  -0.27276D-01   0.20393D-03  -0.41402D-01   0.71266D-03
Inertial Attitude Sensors        31001    -0.33803D-01  -0.55121D-03  -0.27276D-01   0.20393D-03  -0.41402D-01   0.71266D-03
Inertial Attitude Sensors        31001    -0.33803D-01  -0.55121D-03  -0.27276D-01   0.20393D-03  -0.41402D-01   0.71266D-03
Inertial Attitude Sensors        31001    -0.33803D-01  -0.55121D-03  -0.27276D-01   0.20393D-03  -0.41402D-01   0.71266D-03
Inertial Attitude Sensors        31001    -0.33803D-01  -0.55121D-03  -0.27276D-01   0.20393D-03  -0.41402D-01   0.71266D-03
Inertial Attitude Sensors        31001    -0.33803D-01  -0.55121D-03  -0.27276D-01   0.20393D-03  -0.41402D-01   0.71266D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.34163D-01   0.22891D-03   0.17831D-01
Accelerometers                   31002    -0.34163D-01   0.22891D-03   0.17831D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.12404D+00  -0.67738D-03  -0.90643D-01   0.89503D-04  -0.39469D-01   0.62689D-03

MODE# 12/ 19, Frequency (rad/sec), Damping (zeta), Generalized Mass=    121.96       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.53421D-03   0.32549D-01   0.57343D-03   0.80202D-02   0.99240D-06  -0.47644D-02
Reaction Wheel #2 CG             58042    -0.25770D-02   0.28356D-01  -0.61599D-02   0.86392D-02   0.13885D-03  -0.36673D-02
Reaction Wheel #3 CG             58043     0.30156D-02   0.28099D-01   0.62099D-02   0.85363D-02  -0.38015D-03  -0.33694D-02

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.64108D-03  -0.12806D-02   0.12058D-02   0.88154D-02  -0.39124D-04  -0.41276D-02
Inertial Attitude Sensors        31001     0.64108D-03  -0.12806D-02   0.12058D-02   0.88154D-02  -0.39124D-04  -0.41276D-02
Inertial Attitude Sensors        31001     0.64108D-03  -0.12806D-02   0.12058D-02   0.88154D-02  -0.39124D-04  -0.41276D-02
Inertial Attitude Sensors        31001     0.64108D-03  -0.12806D-02   0.12058D-02   0.88154D-02  -0.39124D-04  -0.41276D-02
Inertial Attitude Sensors        31001     0.64108D-03  -0.12806D-02   0.12058D-02   0.88154D-02  -0.39124D-04  -0.41276D-02
Inertial Attitude Sensors        31001     0.64108D-03  -0.12806D-02   0.12058D-02   0.88154D-02  -0.39124D-04  -0.41276D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.28613D-02  -0.56914D-02   0.58974D-02
Accelerometers                   31002     0.28613D-02  -0.56914D-02   0.58974D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.27796D-03   0.41434D-01   0.11513D-03   0.34820D-02  -0.88313D-04  -0.12106D-01

MODE# 13/ 20, Frequency (rad/sec), Damping (zeta), Generalized Mass=    127.18       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.40599D-01   0.32282D-02   0.75273D-01   0.11818D-02   0.15170D-01  -0.39912D-03
Reaction Wheel #2 CG             58042    -0.39035D-01   0.16062D-02   0.59028D-01  -0.46906D-03   0.11587D-01  -0.15628D-02
Reaction Wheel #3 CG             58043    -0.37629D-01   0.29346D-02   0.59216D-01   0.21050D-02   0.11412D-01  -0.15114D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.12868D-01  -0.29960D-03   0.74741D-01   0.96468D-03   0.12833D-01  -0.97301D-03
Inertial Attitude Sensors        31001     0.12868D-01  -0.29960D-03   0.74741D-01   0.96468D-03   0.12833D-01  -0.97301D-03
Inertial Attitude Sensors        31001     0.12868D-01  -0.29960D-03   0.74741D-01   0.96468D-03   0.12833D-01  -0.97301D-03
Inertial Attitude Sensors        31001     0.12868D-01  -0.29960D-03   0.74741D-01   0.96468D-03   0.12833D-01  -0.97301D-03
Inertial Attitude Sensors        31001     0.12868D-01  -0.29960D-03   0.74741D-01   0.96468D-03   0.12833D-01  -0.97301D-03
Inertial Attitude Sensors        31001     0.12868D-01  -0.29960D-03   0.74741D-01   0.96468D-03   0.12833D-01  -0.97301D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.13597D-01  -0.13321D-02   0.61006D-01
Accelerometers                   31002     0.13597D-01  -0.13321D-02   0.61006D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.36281D-01   0.50611D-02   0.92474D-01   0.55229D-03   0.13242D-01  -0.18198D-02

MODE# 14/ 21, Frequency (rad/sec), Damping (zeta), Generalized Mass=    131.64       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.50428D-01  -0.15878D-02  -0.53538D-01  -0.39600D-03   0.13076D-01   0.36977D-03
Reaction Wheel #2 CG             58042    -0.52041D-01   0.15442D-03  -0.71537D-01   0.22307D-02   0.15234D-01  -0.19342D-02
Reaction Wheel #3 CG             58043    -0.51940D-01  -0.28718D-02  -0.73428D-01  -0.28529D-02   0.15850D-01   0.96109D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.98510D-02   0.27948D-03  -0.55272D-01  -0.41711D-03   0.15397D-01   0.28985D-03
Inertial Attitude Sensors        31001     0.98510D-02   0.27948D-03  -0.55272D-01  -0.41711D-03   0.15397D-01   0.28985D-03
Inertial Attitude Sensors        31001     0.98510D-02   0.27948D-03  -0.55272D-01  -0.41711D-03   0.15397D-01   0.28985D-03
Inertial Attitude Sensors        31001     0.98510D-02   0.27948D-03  -0.55272D-01  -0.41711D-03   0.15397D-01   0.28985D-03
Inertial Attitude Sensors        31001     0.98510D-02   0.27948D-03  -0.55272D-01  -0.41711D-03   0.15397D-01   0.28985D-03
Inertial Attitude Sensors        31001     0.98510D-02   0.27948D-03  -0.55272D-01  -0.41711D-03   0.15397D-01   0.28985D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.95231D-02   0.56438D-03  -0.71972D-01
Accelerometers                   31002     0.95231D-02   0.56438D-03  -0.71972D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.49114D-01  -0.19854D-02  -0.31658D-01  -0.16319D-03   0.12269D-01   0.72004D-03

MODE# 15/ 22, Frequency (rad/sec), Damping (zeta), Generalized Mass=    139.20       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.11118D-02  -0.17137D+00  -0.27342D-02  -0.52259D-01   0.77240D-04   0.34817D-02
Reaction Wheel #2 CG             58042    -0.16670D-02  -0.17600D+00   0.41437D-01  -0.56334D-01  -0.17003D-02  -0.48919D-02
Reaction Wheel #3 CG             58043    -0.75910D-03  -0.17683D+00  -0.40140D-01  -0.55469D-01   0.37687D-02  -0.71756D-02

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.46705D-03   0.53393D-01  -0.69584D-02  -0.58277D-01   0.34256D-03  -0.32622D-02
Inertial Attitude Sensors        31001     0.46705D-03   0.53393D-01  -0.69584D-02  -0.58277D-01   0.34256D-03  -0.32622D-02
Inertial Attitude Sensors        31001     0.46705D-03   0.53393D-01  -0.69584D-02  -0.58277D-01   0.34256D-03  -0.32622D-02
Inertial Attitude Sensors        31001     0.46705D-03   0.53393D-01  -0.69584D-02  -0.58277D-01   0.34256D-03  -0.32622D-02
Inertial Attitude Sensors        31001     0.46705D-03   0.53393D-01  -0.69584D-02  -0.58277D-01   0.34256D-03  -0.32622D-02
Inertial Attitude Sensors        31001     0.46705D-03   0.53393D-01  -0.69584D-02  -0.58277D-01   0.34256D-03  -0.32622D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.21090D-02   0.49200D-01  -0.37852D-01
Accelerometers                   31002     0.21090D-02   0.49200D-01  -0.37852D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.58598D-03  -0.18296D+00   0.67412D-03  -0.27664D-01   0.11115D-02   0.44791D-01

MODE# 16/ 23, Frequency (rad/sec), Damping (zeta), Generalized Mass=    179.56       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.90183D-02  -0.26638D+00  -0.22111D-02  -0.60487D-01  -0.96779D-03   0.82404D-01
Reaction Wheel #2 CG             58042     0.43354D-01  -0.19611D+00   0.56780D-01  -0.73826D-01  -0.15799D-02   0.64336D-01
Reaction Wheel #3 CG             58043    -0.49951D-01  -0.19122D+00  -0.51006D-01  -0.71734D-01   0.31451D-02   0.59724D-01

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001    -0.15192D-01   0.13416D-01  -0.82549D-02  -0.76742D-01  -0.13637D-04   0.78784D-01
Inertial Attitude Sensors        31001    -0.15192D-01   0.13416D-01  -0.82549D-02  -0.76742D-01  -0.13637D-04   0.78784D-01
Inertial Attitude Sensors        31001    -0.15192D-01   0.13416D-01  -0.82549D-02  -0.76742D-01  -0.13637D-04   0.78784D-01
Inertial Attitude Sensors        31001    -0.15192D-01   0.13416D-01  -0.82549D-02  -0.76742D-01  -0.13637D-04   0.78784D-01
Inertial Attitude Sensors        31001    -0.15192D-01   0.13416D-01  -0.82549D-02  -0.76742D-01  -0.13637D-04   0.78784D-01
Inertial Attitude Sensors        31001    -0.15192D-01   0.13416D-01  -0.82549D-02  -0.76742D-01  -0.13637D-04   0.78784D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.57745D-01   0.97678D-01  -0.48057D-01
Accelerometers                   31002    -0.57745D-01   0.97678D-01  -0.48057D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.47018D-02  -0.45287D+00  -0.21560D-03   0.40837D-01   0.23534D-03   0.24598D+00

MODE# 17/ 24, Frequency (rad/sec), Damping (zeta), Generalized Mass=    183.12       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.10234D+00  -0.10301D-01  -0.38057D-01  -0.33340D-02  -0.32543D-01   0.24547D-02
Reaction Wheel #2 CG             58042     0.10328D+00  -0.78564D-02   0.37486D-02  -0.48883D-02  -0.27667D-01   0.10093D-01
Reaction Wheel #3 CG             58043     0.96899D-01  -0.50646D-02   0.20213D-02  -0.11517D-02  -0.28446D-01  -0.12043D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001    -0.26206D-01   0.53537D-03  -0.34833D-01  -0.32354D-02  -0.31363D-01   0.39586D-02
Inertial Attitude Sensors        31001    -0.26206D-01   0.53537D-03  -0.34833D-01  -0.32354D-02  -0.31363D-01   0.39586D-02
Inertial Attitude Sensors        31001    -0.26206D-01   0.53537D-03  -0.34833D-01  -0.32354D-02  -0.31363D-01   0.39586D-02
Inertial Attitude Sensors        31001    -0.26206D-01   0.53537D-03  -0.34833D-01  -0.32354D-02  -0.31363D-01   0.39586D-02
Inertial Attitude Sensors        31001    -0.26206D-01   0.53537D-03  -0.34833D-01  -0.32354D-02  -0.31363D-01   0.39586D-02
Inertial Attitude Sensors        31001    -0.26206D-01   0.53537D-03  -0.34833D-01  -0.32354D-02  -0.31363D-01   0.39586D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.28631D-01   0.48049D-02  -0.20775D-02
Accelerometers                   31002    -0.28631D-01   0.48049D-02  -0.20775D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.94471D-01  -0.20040D-01  -0.75790D-01   0.12893D-02  -0.26724D-01   0.11087D-01

MODE# 18/ 27, Frequency (rad/sec), Damping (zeta), Generalized Mass=    222.22       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.25582D-02   0.55122D-01   0.10842D-02   0.86708D-02   0.13495D-02  -0.31007D-01
Reaction Wheel #2 CG             58042    -0.17015D-01   0.27864D-01  -0.10809D-01   0.13624D-01   0.33509D-03  -0.25969D-01
Reaction Wheel #3 CG             58043     0.17583D-01   0.25617D-01   0.86788D-02   0.12888D-01   0.14153D-02  -0.24820D-01

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.87125D-02   0.11191D-01   0.21711D-02   0.14240D-01   0.67938D-03  -0.35005D-01
Inertial Attitude Sensors        31001     0.87125D-02   0.11191D-01   0.21711D-02   0.14240D-01   0.67938D-03  -0.35005D-01
Inertial Attitude Sensors        31001     0.87125D-02   0.11191D-01   0.21711D-02   0.14240D-01   0.67938D-03  -0.35005D-01
Inertial Attitude Sensors        31001     0.87125D-02   0.11191D-01   0.21711D-02   0.14240D-01   0.67938D-03  -0.35005D-01
Inertial Attitude Sensors        31001     0.87125D-02   0.11191D-01   0.21711D-02   0.14240D-01   0.67938D-03  -0.35005D-01
Inertial Attitude Sensors        31001     0.87125D-02   0.11191D-01   0.21711D-02   0.14240D-01   0.67938D-03  -0.35005D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.27635D-01  -0.26464D-01   0.87567D-02
Accelerometers                   31002     0.27635D-01  -0.26464D-01   0.87567D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.14250D-02   0.13399D+00   0.27540D-02  -0.37295D-01   0.14612D-02  -0.10203D+00

MODE# 19/ 28, Frequency (rad/sec), Damping (zeta), Generalized Mass=    225.48       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.74967D-01  -0.15287D-02  -0.23617D-01  -0.15749D-02  -0.23238D-01   0.28752D-03
Reaction Wheel #2 CG             58042     0.75875D-01  -0.11226D-02   0.70946D-02  -0.35550D-02  -0.18632D-01   0.10591D-01
Reaction Wheel #3 CG             58043     0.71359D-01   0.24035D-02   0.78572D-02   0.15332D-02  -0.20057D-01  -0.22264D-02

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001    -0.18676D-01   0.87045D-03  -0.20322D-01  -0.10776D-02  -0.23086D-01   0.17430D-02
Inertial Attitude Sensors        31001    -0.18676D-01   0.87045D-03  -0.20322D-01  -0.10776D-02  -0.23086D-01   0.17430D-02
Inertial Attitude Sensors        31001    -0.18676D-01   0.87045D-03  -0.20322D-01  -0.10776D-02  -0.23086D-01   0.17430D-02
Inertial Attitude Sensors        31001    -0.18676D-01   0.87045D-03  -0.20322D-01  -0.10776D-02  -0.23086D-01   0.17430D-02
Inertial Attitude Sensors        31001    -0.18676D-01   0.87045D-03  -0.20322D-01  -0.10776D-02  -0.23086D-01   0.17430D-02
Inertial Attitude Sensors        31001    -0.18676D-01   0.87045D-03  -0.20322D-01  -0.10776D-02  -0.23086D-01   0.17430D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.19978D-01   0.27808D-02   0.46684D-02
Accelerometers                   31002    -0.19978D-01   0.27808D-02   0.46684D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.67307D-01  -0.71180D-02  -0.48187D-01   0.75072D-03  -0.19967D-01   0.48725D-02

MODE# 20/ 29, Frequency (rad/sec), Damping (zeta), Generalized Mass=    261.47       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.88784D-01  -0.55320D-01  -0.43847D-03   0.21899D-01  -0.96641D-02  -0.31322D-01
Reaction Wheel #2 CG             58042     0.62969D-01  -0.83875D-01  -0.91308D-02   0.23426D-02   0.26150D-02  -0.17278D-02
Reaction Wheel #3 CG             58043     0.35789D-01  -0.80964D-01   0.35163D-02   0.13603D-01   0.23719D-01   0.22984D-01

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.59883D-01  -0.11357D+00   0.19472D-02   0.39056D-01   0.83464D-02   0.10924D-01
Inertial Attitude Sensors        31001     0.59883D-01  -0.11357D+00   0.19472D-02   0.39056D-01   0.83464D-02   0.10924D-01
Inertial Attitude Sensors        31001     0.59883D-01  -0.11357D+00   0.19472D-02   0.39056D-01   0.83464D-02   0.10924D-01
Inertial Attitude Sensors        31001     0.59883D-01  -0.11357D+00   0.19472D-02   0.39056D-01   0.83464D-02   0.10924D-01
Inertial Attitude Sensors        31001     0.59883D-01  -0.11357D+00   0.19472D-02   0.39056D-01   0.83464D-02   0.10924D-01
Inertial Attitude Sensors        31001     0.59883D-01  -0.11357D+00   0.19472D-02   0.39056D-01   0.83464D-02   0.10924D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.54801D-01  -0.97760D-01   0.67570D-02
Accelerometers                   31002     0.54801D-01  -0.97760D-01   0.67570D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.16355D+00  -0.24728D-01   0.85692D-01  -0.65430D-01   0.15601D+00   0.92075D-02

MODE# 21/ 30, Frequency (rad/sec), Damping (zeta), Generalized Mass=    282.22       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.84625D-01   0.38864D-02   0.13614D-01  -0.23304D-01  -0.19769D-01   0.47062D-01
Reaction Wheel #2 CG             58042    -0.81709D-02   0.40103D-01   0.18531D-01   0.97072D-02   0.18163D-01  -0.85334D-01
Reaction Wheel #3 CG             58043     0.61730D-01   0.39304D-01   0.12969D-01   0.14131D-01  -0.82634D-02  -0.88291D-02

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.43834D-01   0.70146D-01  -0.26268D-02  -0.31625D-01   0.73711D-02  -0.25595D-01
Inertial Attitude Sensors        31001     0.43834D-01   0.70146D-01  -0.26268D-02  -0.31625D-01   0.73711D-02  -0.25595D-01
Inertial Attitude Sensors        31001     0.43834D-01   0.70146D-01  -0.26268D-02  -0.31625D-01   0.73711D-02  -0.25595D-01
Inertial Attitude Sensors        31001     0.43834D-01   0.70146D-01  -0.26268D-02  -0.31625D-01   0.73711D-02  -0.25595D-01
Inertial Attitude Sensors        31001     0.43834D-01   0.70146D-01  -0.26268D-02  -0.31625D-01   0.73711D-02  -0.25595D-01
Inertial Attitude Sensors        31001     0.43834D-01   0.70146D-01  -0.26268D-02  -0.31625D-01   0.73711D-02  -0.25595D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.59052D-01   0.38249D-01  -0.24301D-01
Accelerometers                   31002     0.59052D-01   0.38249D-01  -0.24301D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.19769D+00  -0.86559D-01   0.13571D+00   0.17333D+00   0.21973D+00   0.14969D+00

MODE# 22/ 31, Frequency (rad/sec), Damping (zeta), Generalized Mass=    293.17       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.70150D-01   0.30340D-01   0.83129D-02   0.36852D-02   0.10258D-01   0.15013D-02
Reaction Wheel #2 CG             58042    -0.66147D-01   0.33959D-01  -0.13053D-01   0.71456D-02   0.20792D-02  -0.13130D-01
Reaction Wheel #3 CG             58043    -0.59970D-01   0.38350D-01  -0.23195D-03   0.72227D-02  -0.39407D-02   0.14196D-01

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001    -0.20337D-01   0.24460D-04   0.74056D-02   0.47376D-02   0.12983D-01   0.99678D-02
Inertial Attitude Sensors        31001    -0.20337D-01   0.24460D-04   0.74056D-02   0.47376D-02   0.12983D-01   0.99678D-02
Inertial Attitude Sensors        31001    -0.20337D-01   0.24460D-04   0.74056D-02   0.47376D-02   0.12983D-01   0.99678D-02
Inertial Attitude Sensors        31001    -0.20337D-01   0.24460D-04   0.74056D-02   0.47376D-02   0.12983D-01   0.99678D-02
Inertial Attitude Sensors        31001    -0.20337D-01   0.24460D-04   0.74056D-02   0.47376D-02   0.12983D-01   0.99678D-02
Inertial Attitude Sensors        31001    -0.20337D-01   0.24460D-04   0.74056D-02   0.47376D-02   0.12983D-01   0.99678D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.25379D-01   0.10576D-01  -0.46566D-02
Accelerometers                   31002    -0.25379D-01   0.10576D-01  -0.46566D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.77272D-01   0.45847D-01  -0.10039D-02  -0.61972D-02  -0.22600D-01  -0.40789D-01

MODE# 23/ 32, Frequency (rad/sec), Damping (zeta), Generalized Mass=    306.89       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.48814D-02  -0.98564D-01   0.58139D-01   0.48564D-01   0.33910D-01  -0.28856D-02
Reaction Wheel #2 CG             58042     0.51117D-01  -0.11997D+00   0.23766D-01   0.15961D-01   0.80377D-02   0.43298D-01
Reaction Wheel #3 CG             58043     0.38131D-02  -0.11273D+00   0.50453D-01   0.34103D-01   0.24706D-01   0.84524D-03

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.63669D-01  -0.18297D+00   0.32354D-01   0.25348D-01   0.72412D-02  -0.62239D-02
Inertial Attitude Sensors        31001     0.63669D-01  -0.18297D+00   0.32354D-01   0.25348D-01   0.72412D-02  -0.62239D-02
Inertial Attitude Sensors        31001     0.63669D-01  -0.18297D+00   0.32354D-01   0.25348D-01   0.72412D-02  -0.62239D-02
Inertial Attitude Sensors        31001     0.63669D-01  -0.18297D+00   0.32354D-01   0.25348D-01   0.72412D-02  -0.62239D-02
Inertial Attitude Sensors        31001     0.63669D-01  -0.18297D+00   0.32354D-01   0.25348D-01   0.72412D-02  -0.62239D-02
Inertial Attitude Sensors        31001     0.63669D-01  -0.18297D+00   0.32354D-01   0.25348D-01   0.72412D-02  -0.62239D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.65395D-01  -0.18745D+00   0.38927D-01
Accelerometers                   31002     0.65395D-01  -0.18745D+00   0.38927D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.28679D-02  -0.15541D+00   0.63124D-01   0.30365D-01  -0.44074D-02   0.13210D+00

MODE# 24/ 33, Frequency (rad/sec), Damping (zeta), Generalized Mass=    314.43       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.57233D-01   0.70927D-01  -0.37531D-01   0.17063D-01  -0.40897D-01  -0.11212D+00
Reaction Wheel #2 CG             58042    -0.97522D-01  -0.25528D-01  -0.24044D-01   0.35628D-01  -0.54992D-01  -0.90158D-01
Reaction Wheel #3 CG             58043    -0.74935D-02  -0.25587D-01   0.24287D-01   0.38843D-01  -0.28474D-01  -0.79406D-01

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001    -0.14058D+00  -0.83031D-01   0.65749D-03   0.24463D-01   0.59431D-02  -0.29872D-01
Inertial Attitude Sensors        31001    -0.14058D+00  -0.83031D-01   0.65749D-03   0.24463D-01   0.59431D-02  -0.29872D-01
Inertial Attitude Sensors        31001    -0.14058D+00  -0.83031D-01   0.65749D-03   0.24463D-01   0.59431D-02  -0.29872D-01
Inertial Attitude Sensors        31001    -0.14058D+00  -0.83031D-01   0.65749D-03   0.24463D-01   0.59431D-02  -0.29872D-01
Inertial Attitude Sensors        31001    -0.14058D+00  -0.83031D-01   0.65749D-03   0.24463D-01   0.59431D-02  -0.29872D-01
Inertial Attitude Sensors        31001    -0.14058D+00  -0.83031D-01   0.65749D-03   0.24463D-01   0.59431D-02  -0.29872D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.12006D+00  -0.11679D+00  -0.15440D-02
Accelerometers                   31002    -0.12006D+00  -0.11679D+00  -0.15440D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.12302D+00   0.38125D+00  -0.14704D+00  -0.20106D+00  -0.13595D+00  -0.45850D+00

MODE# 25/ 34, Frequency (rad/sec), Damping (zeta), Generalized Mass=    316.38       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.50962D-01   0.31565D-01  -0.27297D-02   0.34567D-04  -0.87004D-02   0.18734D-01
Reaction Wheel #2 CG             58042     0.46230D-01   0.60866D-01  -0.39489D-03   0.95998D-02   0.90872D-02   0.22906D-01
Reaction Wheel #3 CG             58043     0.39108D-01   0.62033D-01   0.19068D-01   0.94804D-02  -0.13501D-01   0.17663D-01

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.74959D-02   0.30210D-02  -0.34555D-02   0.56725D-02  -0.11165D-01   0.23675D-01
Inertial Attitude Sensors        31001     0.74959D-02   0.30210D-02  -0.34555D-02   0.56725D-02  -0.11165D-01   0.23675D-01
Inertial Attitude Sensors        31001     0.74959D-02   0.30210D-02  -0.34555D-02   0.56725D-02  -0.11165D-01   0.23675D-01
Inertial Attitude Sensors        31001     0.74959D-02   0.30210D-02  -0.34555D-02   0.56725D-02  -0.11165D-01   0.23675D-01
Inertial Attitude Sensors        31001     0.74959D-02   0.30210D-02  -0.34555D-02   0.56725D-02  -0.11165D-01   0.23675D-01
Inertial Attitude Sensors        31001     0.74959D-02   0.30210D-02  -0.34555D-02   0.56725D-02  -0.11165D-01   0.23675D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.57294D-02   0.28810D-01   0.12717D-01
Accelerometers                   31002    -0.57294D-02   0.28810D-01   0.12717D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.66892D-01  -0.69293D-02   0.15564D-01   0.35214D-01   0.34916D-01   0.29392D-01

MODE# 26/ 41, Frequency (rad/sec), Damping (zeta), Generalized Mass=    391.12       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.85807D-01   0.62956D-01   0.19585D-02  -0.10069D-01   0.93949D-03  -0.27439D-01
Reaction Wheel #2 CG             58042     0.27437D-01   0.17575D-01  -0.34945D-01  -0.48398D-02   0.32904D-01  -0.88865D-01
Reaction Wheel #3 CG             58043     0.51600D-01   0.14199D+00   0.34030D-02   0.38392D-01  -0.25028D-02   0.11537D+00

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.11695D+00  -0.13141D-01   0.20068D-01   0.23742D-01   0.38911D-01   0.21508D-01
Inertial Attitude Sensors        31001     0.11695D+00  -0.13141D-01   0.20068D-01   0.23742D-01   0.38911D-01   0.21508D-01
Inertial Attitude Sensors        31001     0.11695D+00  -0.13141D-01   0.20068D-01   0.23742D-01   0.38911D-01   0.21508D-01
Inertial Attitude Sensors        31001     0.11695D+00  -0.13141D-01   0.20068D-01   0.23742D-01   0.38911D-01   0.21508D-01
Inertial Attitude Sensors        31001     0.11695D+00  -0.13141D-01   0.20068D-01   0.23742D-01   0.38911D-01   0.21508D-01
Inertial Attitude Sensors        31001     0.11695D+00  -0.13141D-01   0.20068D-01   0.23742D-01   0.38911D-01   0.21508D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.10691D+00   0.11874D-01  -0.10896D-01
Accelerometers                   31002     0.10691D+00   0.11874D-01  -0.10896D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.11999D+00   0.18865D+00   0.11015D+00  -0.11457D+00   0.11150D+00  -0.25354D+00

MODE# 27/ 43, Frequency (rad/sec), Damping (zeta), Generalized Mass=    398.51       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.44675D-01  -0.50513D+00  -0.46203D-01   0.31952D-01  -0.16807D-01   0.18066D+00
Reaction Wheel #2 CG             58042     0.13698D+00  -0.58133D+00   0.12428D+00  -0.17110D+00  -0.55991D-01   0.35195D-01
Reaction Wheel #3 CG             58043    -0.33903D-01  -0.59074D+00  -0.20532D+00  -0.13954D+00   0.15356D+00  -0.11540D+00

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.37950D-01   0.91814D-01  -0.27305D-01  -0.15103D+00   0.88848D-02  -0.12934D+00
Inertial Attitude Sensors        31001     0.37950D-01   0.91814D-01  -0.27305D-01  -0.15103D+00   0.88848D-02  -0.12934D+00
Inertial Attitude Sensors        31001     0.37950D-01   0.91814D-01  -0.27305D-01  -0.15103D+00   0.88848D-02  -0.12934D+00
Inertial Attitude Sensors        31001     0.37950D-01   0.91814D-01  -0.27305D-01  -0.15103D+00   0.88848D-02  -0.12934D+00
Inertial Attitude Sensors        31001     0.37950D-01   0.91814D-01  -0.27305D-01  -0.15103D+00   0.88848D-02  -0.12934D+00
Inertial Attitude Sensors        31001     0.37950D-01   0.91814D-01  -0.27305D-01  -0.15103D+00   0.88848D-02  -0.12934D+00

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.10801D+00  -0.60112D-01  -0.10873D+00
Accelerometers                   31002     0.10801D+00  -0.60112D-01  -0.10873D+00

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.11224D-01  -0.18191D+01  -0.52962D-01   0.12430D+01  -0.39672D-01   0.25427D+01

MODE# 28/ 45, Frequency (rad/sec), Damping (zeta), Generalized Mass=    453.24       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.10682D+00   0.11476D+00  -0.14776D-01   0.51984D-01   0.70842D-02  -0.57158D-01
Reaction Wheel #2 CG             58042    -0.15194D+00   0.19345D+00  -0.18952D+00   0.22164D+00   0.39568D-01  -0.63800D-01
Reaction Wheel #3 CG             58043    -0.81393D-01   0.13040D+00   0.42089D-01   0.87400D-01  -0.61418D-01   0.79068D-01

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001    -0.12576D-01  -0.21407D+00   0.18066D-02   0.23525D-01   0.32882D-01   0.56729D-01
Inertial Attitude Sensors        31001    -0.12576D-01  -0.21407D+00   0.18066D-02   0.23525D-01   0.32882D-01   0.56729D-01
Inertial Attitude Sensors        31001    -0.12576D-01  -0.21407D+00   0.18066D-02   0.23525D-01   0.32882D-01   0.56729D-01
Inertial Attitude Sensors        31001    -0.12576D-01  -0.21407D+00   0.18066D-02   0.23525D-01   0.32882D-01   0.56729D-01
Inertial Attitude Sensors        31001    -0.12576D-01  -0.21407D+00   0.18066D-02   0.23525D-01   0.32882D-01   0.56729D-01
Inertial Attitude Sensors        31001    -0.12576D-01  -0.21407D+00   0.18066D-02   0.23525D-01   0.32882D-01   0.56729D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.44482D-01  -0.17248D+00  -0.67754D-02
Accelerometers                   31002    -0.44482D-01  -0.17248D+00  -0.67754D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.14948D+00   0.95308D+00  -0.95597D-01  -0.84018D+00  -0.10016D+00  -0.15653D+01

MODE# 29/ 47, Frequency (rad/sec), Damping (zeta), Generalized Mass=    478.76       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.46577D+00   0.23185D-01  -0.16206D+00   0.95032D-02  -0.19060D+00   0.59422D-01
Reaction Wheel #2 CG             58042     0.43979D+00   0.88562D-01   0.42703D-01  -0.11807D+00   0.15848D+00   0.47197D+00
Reaction Wheel #3 CG             58043     0.29346D+00   0.31705D+00   0.19852D+00   0.18282D+00  -0.19433D+00   0.23518D+00

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.11064D-01  -0.63068D-01  -0.38503D-01   0.79362D-01  -0.54026D-01   0.48083D-02
Inertial Attitude Sensors        31001     0.11064D-01  -0.63068D-01  -0.38503D-01   0.79362D-01  -0.54026D-01   0.48083D-02
Inertial Attitude Sensors        31001     0.11064D-01  -0.63068D-01  -0.38503D-01   0.79362D-01  -0.54026D-01   0.48083D-02
Inertial Attitude Sensors        31001     0.11064D-01  -0.63068D-01  -0.38503D-01   0.79362D-01  -0.54026D-01   0.48083D-02
Inertial Attitude Sensors        31001     0.11064D-01  -0.63068D-01  -0.38503D-01   0.79362D-01  -0.54026D-01   0.48083D-02
Inertial Attitude Sensors        31001     0.11064D-01  -0.63068D-01  -0.38503D-01   0.79362D-01  -0.54026D-01   0.48083D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.96738D-02  -0.49379D-01   0.53737D-01
Accelerometers                   31002     0.96738D-02  -0.49379D-01   0.53737D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.55521D+00  -0.25417D+01   0.23488D+00   0.27088D+01   0.39044D+00   0.44920D+01

MODE# 30/ 48, Frequency (rad/sec), Damping (zeta), Generalized Mass=    485.48       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.42050D+00   0.12931D+00  -0.21439D+00  -0.16457D+00  -0.25099D+00  -0.36462D+00
Reaction Wheel #2 CG             58042     0.23356D+00  -0.66835D-01   0.71264D-01  -0.10758D+00  -0.30534D-01   0.57498D-01
Reaction Wheel #3 CG             58043     0.31533D+00   0.57092D-01   0.89571D-01   0.14418D+00  -0.12836D-01  -0.21688D+00

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001    -0.83725D-01  -0.85428D-01  -0.61345D-01  -0.79813D-02  -0.65126D-01   0.67386D-01
Inertial Attitude Sensors        31001    -0.83725D-01  -0.85428D-01  -0.61345D-01  -0.79813D-02  -0.65126D-01   0.67386D-01
Inertial Attitude Sensors        31001    -0.83725D-01  -0.85428D-01  -0.61345D-01  -0.79813D-02  -0.65126D-01   0.67386D-01
Inertial Attitude Sensors        31001    -0.83725D-01  -0.85428D-01  -0.61345D-01  -0.79813D-02  -0.65126D-01   0.67386D-01
Inertial Attitude Sensors        31001    -0.83725D-01  -0.85428D-01  -0.61345D-01  -0.79813D-02  -0.65126D-01   0.67386D-01
Inertial Attitude Sensors        31001    -0.83725D-01  -0.85428D-01  -0.61345D-01  -0.79813D-02  -0.65126D-01   0.67386D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.12548D+00  -0.17153D-01   0.11557D-01
Accelerometers                   31002    -0.12548D+00  -0.17153D-01   0.11557D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.41009D+00   0.65706D+01   0.90367D-01  -0.71249D+01   0.24365D+00  -0.11673D+02

MODE# 31/ 50, Frequency (rad/sec), Damping (zeta), Generalized Mass=    503.65       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.10098D+00   0.19276D-01  -0.11455D+00  -0.13933D+00  -0.14059D+00  -0.30516D+00
Reaction Wheel #2 CG             58042    -0.51261D-01  -0.22465D+00   0.84272D-01  -0.63588D-01  -0.20116D+00  -0.31706D+00
Reaction Wheel #3 CG             58043     0.83709D-01  -0.29528D+00  -0.12412D+00  -0.30181D-01   0.22988D+00  -0.49484D+00

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001    -0.90941D-01   0.55906D-01  -0.35983D-01  -0.10683D+00  -0.28696D-01  -0.72102D-02
Inertial Attitude Sensors        31001    -0.90941D-01   0.55906D-01  -0.35983D-01  -0.10683D+00  -0.28696D-01  -0.72102D-02
Inertial Attitude Sensors        31001    -0.90941D-01   0.55906D-01  -0.35983D-01  -0.10683D+00  -0.28696D-01  -0.72102D-02
Inertial Attitude Sensors        31001    -0.90941D-01   0.55906D-01  -0.35983D-01  -0.10683D+00  -0.28696D-01  -0.72102D-02
Inertial Attitude Sensors        31001    -0.90941D-01   0.55906D-01  -0.35983D-01  -0.10683D+00  -0.28696D-01  -0.72102D-02
Inertial Attitude Sensors        31001    -0.90941D-01   0.55906D-01  -0.35983D-01  -0.10683D+00  -0.28696D-01  -0.72102D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.92644D-01   0.34018D-01  -0.46082D-01
Accelerometers                   31002    -0.92644D-01   0.34018D-01  -0.46082D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.14504D-01  -0.47416D+01  -0.86943D-01   0.55417D+01  -0.38111D-01   0.86609D+01

MODE# 32/ 51, Frequency (rad/sec), Damping (zeta), Generalized Mass=    507.49       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.39319D+00   0.14336D-01  -0.20239D+00  -0.12653D+00  -0.24775D+00  -0.23113D+00
Reaction Wheel #2 CG             58042     0.23301D+00  -0.14963D+00   0.10164D+00  -0.14528D+00  -0.10751D-02   0.10687D+00
Reaction Wheel #3 CG             58043     0.24433D+00  -0.81430D-01   0.33745D-02   0.77710D-01   0.10694D+00  -0.29569D+00

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001    -0.42019D-01  -0.24190D-01  -0.50270D-01  -0.25832D-01  -0.53455D-01   0.40762D-01
Inertial Attitude Sensors        31001    -0.42019D-01  -0.24190D-01  -0.50270D-01  -0.25832D-01  -0.53455D-01   0.40762D-01
Inertial Attitude Sensors        31001    -0.42019D-01  -0.24190D-01  -0.50270D-01  -0.25832D-01  -0.53455D-01   0.40762D-01
Inertial Attitude Sensors        31001    -0.42019D-01  -0.24190D-01  -0.50270D-01  -0.25832D-01  -0.53455D-01   0.40762D-01
Inertial Attitude Sensors        31001    -0.42019D-01  -0.24190D-01  -0.50270D-01  -0.25832D-01  -0.53455D-01   0.40762D-01
Inertial Attitude Sensors        31001    -0.42019D-01  -0.24190D-01  -0.50270D-01  -0.25832D-01  -0.53455D-01   0.40762D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.68290D-01   0.18743D-01  -0.21586D-02
Accelerometers                   31002    -0.68290D-01   0.18743D-01  -0.21586D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.40633D+00  -0.34556D+00   0.16759D+00   0.44530D+00   0.31451D+00   0.62713D+00

MODE# 33/ 52, Frequency (rad/sec), Damping (zeta), Generalized Mass=    527.33       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.11700D+00  -0.25441D+00   0.19707D+00   0.36895D+00   0.16560D+00   0.76315D+00
Reaction Wheel #2 CG             58042    -0.23014D+00   0.12143D+00  -0.15256D+00   0.45455D+00  -0.37398D-02  -0.49409D+00
Reaction Wheel #3 CG             58043     0.91005D-02   0.10700D+00   0.18097D+00   0.21644D+00  -0.20442D+00   0.19722D+00

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.51894D-01  -0.54119D-01   0.46082D-01   0.10208D+00   0.78845D-02   0.80117D-01
Inertial Attitude Sensors        31001     0.51894D-01  -0.54119D-01   0.46082D-01   0.10208D+00   0.78845D-02   0.80117D-01
Inertial Attitude Sensors        31001     0.51894D-01  -0.54119D-01   0.46082D-01   0.10208D+00   0.78845D-02   0.80117D-01
Inertial Attitude Sensors        31001     0.51894D-01  -0.54119D-01   0.46082D-01   0.10208D+00   0.78845D-02   0.80117D-01
Inertial Attitude Sensors        31001     0.51894D-01  -0.54119D-01   0.46082D-01   0.10208D+00   0.78845D-02   0.80117D-01
Inertial Attitude Sensors        31001     0.51894D-01  -0.54119D-01   0.46082D-01   0.10208D+00   0.78845D-02   0.80117D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.10272D-01   0.49654D-01   0.72915D-01
Accelerometers                   31002     0.10272D-01   0.49654D-01   0.72915D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.23557D+00   0.24278D+01   0.37216D+00  -0.28753D+01   0.41724D+00  -0.44868D+01

MODE# 34/ 53, Frequency (rad/sec), Damping (zeta), Generalized Mass=    528.70       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.19111D+00   0.55682D-01  -0.13444D+00  -0.14112D+00  -0.13598D+00  -0.26743D+00
Reaction Wheel #2 CG             58042     0.13304D+00  -0.54415D-01   0.32510D-01  -0.10548D+00   0.59788D-01   0.19007D+00
Reaction Wheel #3 CG             58043     0.68355D-01  -0.13589D+00  -0.11901D+00  -0.94688D-01   0.21595D+00  -0.26729D+00

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001    -0.10487D-01  -0.47474D-02  -0.26132D-01  -0.28451D-01  -0.17028D-01   0.80656D-02
Inertial Attitude Sensors        31001    -0.10487D-01  -0.47474D-02  -0.26132D-01  -0.28451D-01  -0.17028D-01   0.80656D-02
Inertial Attitude Sensors        31001    -0.10487D-01  -0.47474D-02  -0.26132D-01  -0.28451D-01  -0.17028D-01   0.80656D-02
Inertial Attitude Sensors        31001    -0.10487D-01  -0.47474D-02  -0.26132D-01  -0.28451D-01  -0.17028D-01   0.80656D-02
Inertial Attitude Sensors        31001    -0.10487D-01  -0.47474D-02  -0.26132D-01  -0.28451D-01  -0.17028D-01   0.80656D-02
Inertial Attitude Sensors        31001    -0.10487D-01  -0.47474D-02  -0.26132D-01  -0.28451D-01  -0.17028D-01   0.80656D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.16530D-01   0.18347D-02  -0.18813D-01
Accelerometers                   31002    -0.16530D-01   0.18347D-02  -0.18813D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.98304D-01  -0.31888D+00   0.72201D-02   0.38320D+00   0.47376D-01   0.57250D+00

MODE# 35/ 54, Frequency (rad/sec), Damping (zeta), Generalized Mass=    529.80       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.14271D+00   0.58751D-01   0.96402D-01  -0.32836D-01   0.22984D+00  -0.95474D-01
Reaction Wheel #2 CG             58042     0.26706D+00  -0.85114D-01   0.13707D+00  -0.42978D+00   0.20239D+00   0.71258D+00
Reaction Wheel #3 CG             58043    -0.74476D-01   0.12387D-02  -0.11397D+00  -0.20274D+00   0.63749D-01   0.15776D+00

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.10140D+00  -0.78236D-01   0.81596D-02   0.13520D-01   0.34145D-01   0.61609D-01
Inertial Attitude Sensors        31001     0.10140D+00  -0.78236D-01   0.81596D-02   0.13520D-01   0.34145D-01   0.61609D-01
Inertial Attitude Sensors        31001     0.10140D+00  -0.78236D-01   0.81596D-02   0.13520D-01   0.34145D-01   0.61609D-01
Inertial Attitude Sensors        31001     0.10140D+00  -0.78236D-01   0.81596D-02   0.13520D-01   0.34145D-01   0.61609D-01
Inertial Attitude Sensors        31001     0.10140D+00  -0.78236D-01   0.81596D-02   0.13520D-01   0.34145D-01   0.61609D-01
Inertial Attitude Sensors        31001     0.10140D+00  -0.78236D-01   0.81596D-02   0.13520D-01   0.34145D-01   0.61609D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.71504D-01  -0.32426D-03  -0.30268D-01
Accelerometers                   31002     0.71504D-01  -0.32426D-03  -0.30268D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.29160D+00   0.44215D+00  -0.22776D+00  -0.63118D+00  -0.38648D+00  -0.96064D+00

MODE# 36/ 57, Frequency (rad/sec), Damping (zeta), Generalized Mass=    534.38       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.17030D+00  -0.41911D-01   0.12204D+00   0.77632D-01   0.21800D+00   0.13601D+00
Reaction Wheel #2 CG             58042     0.11708D+00  -0.71139D-01   0.69864D-01  -0.21745D+00   0.11478D+00   0.36103D+00
Reaction Wheel #3 CG             58043    -0.98536D-01  -0.76529D-01  -0.12309D+00  -0.17459D+00   0.97049D-01   0.77645D-01

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.84445D-01  -0.43580D-01   0.13006D-01   0.17940D-02   0.29600D-01   0.52096D-01
Inertial Attitude Sensors        31001     0.84445D-01  -0.43580D-01   0.13006D-01   0.17940D-02   0.29600D-01   0.52096D-01
Inertial Attitude Sensors        31001     0.84445D-01  -0.43580D-01   0.13006D-01   0.17940D-02   0.29600D-01   0.52096D-01
Inertial Attitude Sensors        31001     0.84445D-01  -0.43580D-01   0.13006D-01   0.17940D-02   0.29600D-01   0.52096D-01
Inertial Attitude Sensors        31001     0.84445D-01  -0.43580D-01   0.13006D-01   0.17940D-02   0.29600D-01   0.52096D-01
Inertial Attitude Sensors        31001     0.84445D-01  -0.43580D-01   0.13006D-01   0.17940D-02   0.29600D-01   0.52096D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.58854D-01   0.21551D-01  -0.25124D-01
Accelerometers                   31002     0.58854D-01   0.21551D-01  -0.25124D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.23565D+00   0.84128D+00  -0.15170D+00  -0.11054D+01  -0.27317D+00  -0.16794D+01

MODE# 37/ 59, Frequency (rad/sec), Damping (zeta), Generalized Mass=    539.82       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.28800D+00   0.75729D-01  -0.20323D+00  -0.18817D+00  -0.28343D+00  -0.33989D+00
Reaction Wheel #2 CG             58042     0.72836D-01  -0.32862D-01   0.26926D-01  -0.33882D-01  -0.23788D-01   0.81362D-04
Reaction Wheel #3 CG             58043     0.11011D+00  -0.48968D-01  -0.11646D-01   0.38368D-01   0.10995D+00  -0.24194D+00

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001    -0.47442D-01   0.99804D-02  -0.34559D-01  -0.44593D-02  -0.31241D-01  -0.15143D-01
Inertial Attitude Sensors        31001    -0.47442D-01   0.99804D-02  -0.34559D-01  -0.44593D-02  -0.31241D-01  -0.15143D-01
Inertial Attitude Sensors        31001    -0.47442D-01   0.99804D-02  -0.34559D-01  -0.44593D-02  -0.31241D-01  -0.15143D-01
Inertial Attitude Sensors        31001    -0.47442D-01   0.99804D-02  -0.34559D-01  -0.44593D-02  -0.31241D-01  -0.15143D-01
Inertial Attitude Sensors        31001    -0.47442D-01   0.99804D-02  -0.34559D-01  -0.44593D-02  -0.31241D-01  -0.15143D-01
Inertial Attitude Sensors        31001    -0.47442D-01   0.99804D-02  -0.34559D-01  -0.44593D-02  -0.31241D-01  -0.15143D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.42383D-01  -0.10371D-01   0.22981D-02
Accelerometers                   31002    -0.42383D-01  -0.10371D-01   0.22981D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.27622D+00  -0.51000D+00   0.15681D+00   0.66386D+00   0.27791D+00   0.99421D+00

MODE# 38/ 62, Frequency (rad/sec), Damping (zeta), Generalized Mass=    548.73       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.29901D+00   0.18713D+00  -0.25067D+00  -0.34338D+00  -0.34980D+00  -0.60197D+00
Reaction Wheel #2 CG             58042    -0.17426D+00   0.28265D+00  -0.28034D+00   0.41035D+00   0.77712D-01  -0.25942D+00
Reaction Wheel #3 CG             58043    -0.34158D-01   0.11175D+00  -0.68913D-02  -0.57080D-01  -0.86454D-01   0.24010D+00

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.28318D-01  -0.37261D-01   0.21947D-01  -0.70406D-01   0.77731D-02   0.24216D-01
Inertial Attitude Sensors        31001     0.28318D-01  -0.37261D-01   0.21947D-01  -0.70406D-01   0.77731D-02   0.24216D-01
Inertial Attitude Sensors        31001     0.28318D-01  -0.37261D-01   0.21947D-01  -0.70406D-01   0.77731D-02   0.24216D-01
Inertial Attitude Sensors        31001     0.28318D-01  -0.37261D-01   0.21947D-01  -0.70406D-01   0.77731D-02   0.24216D-01
Inertial Attitude Sensors        31001     0.28318D-01  -0.37261D-01   0.21947D-01  -0.70406D-01   0.77731D-02   0.24216D-01
Inertial Attitude Sensors        31001     0.28318D-01  -0.37261D-01   0.21947D-01  -0.70406D-01   0.77731D-02   0.24216D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.18522D-01  -0.16171D-01  -0.21236D-01
Accelerometers                   31002     0.18522D-01  -0.16171D-01  -0.21236D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.61093D+00  -0.69057D+00   0.61213D+00   0.91177D+00   0.88514D+00   0.13579D+01

MODE# 39/ 63, Frequency (rad/sec), Damping (zeta), Generalized Mass=    551.93       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.59820D+00   0.34532D+00  -0.49298D+00  -0.72001D+00  -0.71430D+00  -0.12330D+01
Reaction Wheel #2 CG             58042    -0.26993D+00   0.40567D+00  -0.39062D+00   0.58674D+00   0.63925D-01  -0.45685D+00
Reaction Wheel #3 CG             58043    -0.78717D-01   0.86672D-01  -0.80700D-01  -0.18823D+00  -0.30226D-01   0.29260D+00

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.29041D-01  -0.13188D-01   0.48506D-01  -0.13416D+00   0.89626D-02   0.27107D-01
Inertial Attitude Sensors        31001     0.29041D-01  -0.13188D-01   0.48506D-01  -0.13416D+00   0.89626D-02   0.27107D-01
Inertial Attitude Sensors        31001     0.29041D-01  -0.13188D-01   0.48506D-01  -0.13416D+00   0.89626D-02   0.27107D-01
Inertial Attitude Sensors        31001     0.29041D-01  -0.13188D-01   0.48506D-01  -0.13416D+00   0.89626D-02   0.27107D-01
Inertial Attitude Sensors        31001     0.29041D-01  -0.13188D-01   0.48506D-01  -0.13416D+00   0.89626D-02   0.27107D-01
Inertial Attitude Sensors        31001     0.29041D-01  -0.13188D-01   0.48506D-01  -0.13416D+00   0.89626D-02   0.27107D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.19291D-01   0.47968D-02  -0.25202D-01
Accelerometers                   31002     0.19291D-01   0.47968D-02  -0.25202D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.12686D+01  -0.11329D+01   0.12754D+01   0.14749D+01   0.18322D+01   0.22228D+01

MODE# 40/ 64, Frequency (rad/sec), Damping (zeta), Generalized Mass=    553.02       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.14255D+00   0.23238D-01  -0.99368D-01  -0.86694D-01  -0.14957D+00  -0.14692D+00
Reaction Wheel #2 CG             58042     0.91372D-01  -0.63395D-01   0.74646D-01  -0.12701D+00   0.46393D-02   0.12650D+00
Reaction Wheel #3 CG             58043     0.56183D-01  -0.67322D-02   0.17514D-01   0.42330D-01   0.26310D-01  -0.93295D-01

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001    -0.18902D-01   0.84112D-03  -0.18264D-01   0.13776D-01  -0.16987D-01  -0.12290D-01
Inertial Attitude Sensors        31001    -0.18902D-01   0.84112D-03  -0.18264D-01   0.13776D-01  -0.16987D-01  -0.12290D-01
Inertial Attitude Sensors        31001    -0.18902D-01   0.84112D-03  -0.18264D-01   0.13776D-01  -0.16987D-01  -0.12290D-01
Inertial Attitude Sensors        31001    -0.18902D-01   0.84112D-03  -0.18264D-01   0.13776D-01  -0.16987D-01  -0.12290D-01
Inertial Attitude Sensors        31001    -0.18902D-01   0.84112D-03  -0.18264D-01   0.13776D-01  -0.16987D-01  -0.12290D-01
Inertial Attitude Sensors        31001    -0.18902D-01   0.84112D-03  -0.18264D-01   0.13776D-01  -0.16987D-01  -0.12290D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.13688D-01  -0.12621D-01   0.85848D-02
Accelerometers                   31002    -0.13688D-01  -0.12621D-01   0.85848D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.10777D+00  -0.42413D-01   0.47894D-01   0.46970D-01   0.92400D-01   0.80384D-01

MODE# 41/ 66, Frequency (rad/sec), Damping (zeta), Generalized Mass=    569.50       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.60780D+00  -0.25467D+00   0.56487D+00   0.79032D+00   0.67381D+00   0.12983D+01
Reaction Wheel #2 CG             58042     0.76576D+00  -0.72903D+00   0.10299D+01  -0.18784D+01   0.33440D-01   0.17348D+01
Reaction Wheel #3 CG             58043     0.31333D-01   0.15091D+01   0.13331D+01   0.84760D+00  -0.27805D+01   0.33806D+01

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001    -0.83228D-02   0.23241D-01  -0.17818D-01  -0.81973D-02   0.25451D-03  -0.51065D-01
Inertial Attitude Sensors        31001    -0.83228D-02   0.23241D-01  -0.17818D-01  -0.81973D-02   0.25451D-03  -0.51065D-01
Inertial Attitude Sensors        31001    -0.83228D-02   0.23241D-01  -0.17818D-01  -0.81973D-02   0.25451D-03  -0.51065D-01
Inertial Attitude Sensors        31001    -0.83228D-02   0.23241D-01  -0.17818D-01  -0.81973D-02   0.25451D-03  -0.51065D-01
Inertial Attitude Sensors        31001    -0.83228D-02   0.23241D-01  -0.17818D-01  -0.81973D-02   0.25451D-03  -0.51065D-01
Inertial Attitude Sensors        31001    -0.83228D-02   0.23241D-01  -0.17818D-01  -0.81973D-02   0.25451D-03  -0.51065D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.18985D-01  -0.35680D-01  -0.17765D-01
Accelerometers                   31002     0.18985D-01  -0.35680D-01  -0.17765D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.16676D+01  -0.77106D-01   0.17228D+01  -0.65186D-01   0.24601D+01   0.12449D+00

MODE# 42/ 67, Frequency (rad/sec), Damping (zeta), Generalized Mass=    575.82       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.39539D+00   0.28455D+00  -0.28519D+00  -0.89810D+00  -0.59938D+00  -0.15064D+01
Reaction Wheel #2 CG             58042    -0.55572D-01  -0.22243D+00   0.32645D+00  -0.35324D+00  -0.46670D+00  -0.39608D+00
Reaction Wheel #3 CG             58043    -0.47606D+00  -0.10504D+01  -0.88536D+00  -0.10959D+01   0.15294D+01  -0.11802D+01

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.77761D-02  -0.39486D-01   0.94694D-01   0.15913D+00   0.30326D-02   0.31415D-02
Inertial Attitude Sensors        31001     0.77761D-02  -0.39486D-01   0.94694D-01   0.15913D+00   0.30326D-02   0.31415D-02
Inertial Attitude Sensors        31001     0.77761D-02  -0.39486D-01   0.94694D-01   0.15913D+00   0.30326D-02   0.31415D-02
Inertial Attitude Sensors        31001     0.77761D-02  -0.39486D-01   0.94694D-01   0.15913D+00   0.30326D-02   0.31415D-02
Inertial Attitude Sensors        31001     0.77761D-02  -0.39486D-01   0.94694D-01   0.15913D+00   0.30326D-02   0.31415D-02
Inertial Attitude Sensors        31001     0.77761D-02  -0.39486D-01   0.94694D-01   0.15913D+00   0.30326D-02   0.31415D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.11359D-01  -0.15862D-01   0.15086D+00
Accelerometers                   31002     0.11359D-01  -0.15862D-01   0.15086D+00

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.33924D+01  -0.10466D+00   0.37357D+01  -0.19012D-01   0.51245D+01   0.16129D+00

MODE# 43/ 68, Frequency (rad/sec), Damping (zeta), Generalized Mass=    593.08       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.12973D+01   0.65161D+00  -0.11847D+01  -0.23640D+01  -0.18709D+01  -0.38200D+01
Reaction Wheel #2 CG             58042     0.84628D-01  -0.23086D+00   0.29416D+00  -0.47521D+00  -0.25231D+00   0.10854D+00
Reaction Wheel #3 CG             58043    -0.12518D+00   0.51956D+00   0.44552D+00   0.21122D+00  -0.10893D+01   0.14509D+01

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.10277D-01  -0.53028D-02   0.59085D-01   0.61241D-01   0.15230D-01  -0.22156D-01
Inertial Attitude Sensors        31001     0.10277D-01  -0.53028D-02   0.59085D-01   0.61241D-01   0.15230D-01  -0.22156D-01
Inertial Attitude Sensors        31001     0.10277D-01  -0.53028D-02   0.59085D-01   0.61241D-01   0.15230D-01  -0.22156D-01
Inertial Attitude Sensors        31001     0.10277D-01  -0.53028D-02   0.59085D-01   0.61241D-01   0.15230D-01  -0.22156D-01
Inertial Attitude Sensors        31001     0.10277D-01  -0.53028D-02   0.59085D-01   0.61241D-01   0.15230D-01  -0.22156D-01
Inertial Attitude Sensors        31001     0.10277D-01  -0.53028D-02   0.59085D-01   0.61241D-01   0.15230D-01  -0.22156D-01

