                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.26476D-01  -0.20908D-01   0.61921D-01
Accelerometers                   31002     0.26476D-01  -0.20908D-01   0.61921D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.41086D+01   0.14058D+00  -0.41544D+01  -0.42930D+00  -0.59347D+01  -0.33871D+00

MODE# 44/ 69, Frequency (rad/sec), Damping (zeta), Generalized Mass=    596.88       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.15719D+00   0.19975D+00   0.20066D+00  -0.30722D+00   0.31210D+00  -0.54608D+00
Reaction Wheel #2 CG             58042     0.59187D+00  -0.70439D+00   0.94905D+00  -0.17162D+01  -0.35635D+00   0.88570D+00
Reaction Wheel #3 CG             58043    -0.78839D-01  -0.39864D+00  -0.38437D+00  -0.38852D+00   0.87784D+00  -0.93102D+00

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.62825D-02  -0.12483D-01   0.18936D-01   0.11373D-01   0.45364D-02   0.30426D-01
Inertial Attitude Sensors        31001     0.62825D-02  -0.12483D-01   0.18936D-01   0.11373D-01   0.45364D-02   0.30426D-01
Inertial Attitude Sensors        31001     0.62825D-02  -0.12483D-01   0.18936D-01   0.11373D-01   0.45364D-02   0.30426D-01
Inertial Attitude Sensors        31001     0.62825D-02  -0.12483D-01   0.18936D-01   0.11373D-01   0.45364D-02   0.30426D-01
Inertial Attitude Sensors        31001     0.62825D-02  -0.12483D-01   0.18936D-01   0.11373D-01   0.45364D-02   0.30426D-01
Inertial Attitude Sensors        31001     0.62825D-02  -0.12483D-01   0.18936D-01   0.11373D-01   0.45364D-02   0.30426D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.86287D-02   0.22313D-01   0.16263D-01
Accelerometers                   31002    -0.86287D-02   0.22313D-01   0.16263D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.22693D+01  -0.67629D+00  -0.23458D+01   0.10207D+01  -0.33100D+01   0.14269D+01

MODE# 45/ 70, Frequency (rad/sec), Damping (zeta), Generalized Mass=    597.51       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.33890D+00   0.88280D-01   0.39752D+00   0.20860D+00   0.66004D+00   0.31094D+00
Reaction Wheel #2 CG             58042     0.10090D+01  -0.95332D+00   0.13224D+01  -0.25297D+01  -0.12520D+00   0.18760D+01
Reaction Wheel #3 CG             58043     0.47450D-01  -0.67213D+00  -0.62866D+00  -0.44287D+00   0.16184D+01  -0.20017D+01

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001    -0.26442D-01  -0.14523D-01  -0.11611D-01  -0.14644D-01  -0.50305D-02   0.34087D-01
Inertial Attitude Sensors        31001    -0.26442D-01  -0.14523D-01  -0.11611D-01  -0.14644D-01  -0.50305D-02   0.34087D-01
Inertial Attitude Sensors        31001    -0.26442D-01  -0.14523D-01  -0.11611D-01  -0.14644D-01  -0.50305D-02   0.34087D-01
Inertial Attitude Sensors        31001    -0.26442D-01  -0.14523D-01  -0.11611D-01  -0.14644D-01  -0.50305D-02   0.34087D-01
Inertial Attitude Sensors        31001    -0.26442D-01  -0.14523D-01  -0.11611D-01  -0.14644D-01  -0.50305D-02   0.34087D-01
Inertial Attitude Sensors        31001    -0.26442D-01  -0.14523D-01  -0.11611D-01  -0.14644D-01  -0.50305D-02   0.34087D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.46549D-01   0.18806D-01  -0.10538D-01
Accelerometers                   31002    -0.46549D-01   0.18806D-01  -0.10538D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.97063D+00  -0.79883D+00  -0.10611D+01   0.13228D+01  -0.14711D+01   0.17224D+01

MODE# 46/ 71, Frequency (rad/sec), Damping (zeta), Generalized Mass=    602.49       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.59960D+00   0.32587D+00  -0.66020D+00  -0.12658D+01  -0.10051D+01  -0.20556D+01
Reaction Wheel #2 CG             58042     0.41282D-01  -0.63490D+00   0.54831D+00  -0.74473D+00  -0.87942D+00  -0.70652D+00
Reaction Wheel #3 CG             58043     0.32481D+00   0.41827D+00   0.56581D+00   0.10467D+01  -0.52708D+00  -0.30355D+00

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001    -0.17720D-01  -0.43335D-02  -0.29388D-01  -0.20657D-01   0.29218D-01   0.18612D-01
Inertial Attitude Sensors        31001    -0.17720D-01  -0.43335D-02  -0.29388D-01  -0.20657D-01   0.29218D-01   0.18612D-01
Inertial Attitude Sensors        31001    -0.17720D-01  -0.43335D-02  -0.29388D-01  -0.20657D-01   0.29218D-01   0.18612D-01
Inertial Attitude Sensors        31001    -0.17720D-01  -0.43335D-02  -0.29388D-01  -0.20657D-01   0.29218D-01   0.18612D-01
Inertial Attitude Sensors        31001    -0.17720D-01  -0.43335D-02  -0.29388D-01  -0.20657D-01   0.29218D-01   0.18612D-01
Inertial Attitude Sensors        31001    -0.17720D-01  -0.43335D-02  -0.29388D-01  -0.20657D-01   0.29218D-01   0.18612D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.31577D-01   0.15191D-01  -0.69454D-01
Accelerometers                   31002    -0.31577D-01   0.15191D-01  -0.69454D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.24859D+01   0.26103D+00   0.26744D+01  -0.17076D+00   0.37436D+01  -0.52253D+00

MODE# 47/ 72, Frequency (rad/sec), Damping (zeta), Generalized Mass=    604.05       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.49888D+00  -0.29252D+00   0.52217D+00   0.10209D+01   0.76438D+00   0.16333D+01
Reaction Wheel #2 CG             58042    -0.28630D+00   0.57942D+00  -0.61647D+00   0.10726D+01   0.44226D+00  -0.20599D+00
Reaction Wheel #3 CG             58043    -0.22822D+00  -0.17872D+00  -0.24399D+00  -0.62498D+00   0.10272D-01   0.61360D+00

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.52313D-03  -0.25330D-02   0.19608D-01   0.31757D-01  -0.22468D-01  -0.29495D-01
Inertial Attitude Sensors        31001     0.52313D-03  -0.25330D-02   0.19608D-01   0.31757D-01  -0.22468D-01  -0.29495D-01
Inertial Attitude Sensors        31001     0.52313D-03  -0.25330D-02   0.19608D-01   0.31757D-01  -0.22468D-01  -0.29495D-01
Inertial Attitude Sensors        31001     0.52313D-03  -0.25330D-02   0.19608D-01   0.31757D-01  -0.22468D-01  -0.29495D-01
Inertial Attitude Sensors        31001     0.52313D-03  -0.25330D-02   0.19608D-01   0.31757D-01  -0.22468D-01  -0.29495D-01
Inertial Attitude Sensors        31001     0.52313D-03  -0.25330D-02   0.19608D-01   0.31757D-01  -0.22468D-01  -0.29495D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.20402D-01  -0.31692D-01   0.53878D-01
Accelerometers                   31002     0.20402D-01  -0.31692D-01   0.53878D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.19244D+01  -0.21159D+00  -0.20936D+01   0.12253D+00  -0.29075D+01   0.41137D+00

MODE# 48/ 73, Frequency (rad/sec), Damping (zeta), Generalized Mass=    615.12       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.83610D+00  -0.32516D+00  -0.87794D+00   0.10353D+01  -0.14839D+01   0.18331D+01
Reaction Wheel #2 CG             58042     0.10011D+01   0.56226D+00  -0.12173D+00  -0.10867D+01   0.31945D+01   0.56809D+01
Reaction Wheel #3 CG             58043    -0.51972D+00  -0.29975D+00  -0.66030D+00  -0.13055D+01   0.19282D+00   0.98405D+00

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001    -0.31419D-01   0.63611D-01   0.40329D-01   0.15047D-01   0.28212D-01  -0.46198D-01
Inertial Attitude Sensors        31001    -0.31419D-01   0.63611D-01   0.40329D-01   0.15047D-01   0.28212D-01  -0.46198D-01
Inertial Attitude Sensors        31001    -0.31419D-01   0.63611D-01   0.40329D-01   0.15047D-01   0.28212D-01  -0.46198D-01
Inertial Attitude Sensors        31001    -0.31419D-01   0.63611D-01   0.40329D-01   0.15047D-01   0.28212D-01  -0.46198D-01
Inertial Attitude Sensors        31001    -0.31419D-01   0.63611D-01   0.40329D-01   0.15047D-01   0.28212D-01  -0.46198D-01
Inertial Attitude Sensors        31001    -0.31419D-01   0.63611D-01   0.40329D-01   0.15047D-01   0.28212D-01  -0.46198D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.42132D-02   0.69722D-02   0.18128D-01
Accelerometers                   31002    -0.42132D-02   0.69722D-02   0.18128D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.83262D+00   0.44279D+00   0.92592D+00  -0.74159D+00   0.12737D+01  -0.85930D+00

MODE# 49/ 75, Frequency (rad/sec), Damping (zeta), Generalized Mass=    631.76       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.17594D+00  -0.10723D+00  -0.20994D+00   0.43327D+00  -0.42618D+00   0.69931D+00
Reaction Wheel #2 CG             58042     0.46640D-01   0.83292D-02   0.38540D-01  -0.17860D+00   0.21299D+00   0.42949D+00
Reaction Wheel #3 CG             58043    -0.13661D+00  -0.15939D-01  -0.83854D-01  -0.29803D+00  -0.18953D+00   0.49829D+00

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.54441D-02  -0.10668D-01   0.14906D-01   0.14334D-01   0.11342D-01   0.60061D-03
Inertial Attitude Sensors        31001     0.54441D-02  -0.10668D-01   0.14906D-01   0.14334D-01   0.11342D-01   0.60061D-03
Inertial Attitude Sensors        31001     0.54441D-02  -0.10668D-01   0.14906D-01   0.14334D-01   0.11342D-01   0.60061D-03
Inertial Attitude Sensors        31001     0.54441D-02  -0.10668D-01   0.14906D-01   0.14334D-01   0.11342D-01   0.60061D-03
Inertial Attitude Sensors        31001     0.54441D-02  -0.10668D-01   0.14906D-01   0.14334D-01   0.11342D-01   0.60061D-03
Inertial Attitude Sensors        31001     0.54441D-02  -0.10668D-01   0.14906D-01   0.14334D-01   0.11342D-01   0.60061D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.66951D-02  -0.72280D-02   0.57207D-02
Accelerometers                   31002     0.66951D-02  -0.72280D-02   0.57207D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.11241D+00  -0.42629D-01  -0.93581D-01   0.13193D+00  -0.13790D+00   0.97992D-01

MODE# 50/ 76, Frequency (rad/sec), Damping (zeta), Generalized Mass=    632.95       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.92321D+00  -0.82224D+00  -0.10602D+01   0.28482D+01  -0.22121D+01   0.45404D+01
Reaction Wheel #2 CG             58042    -0.25087D+00  -0.36148D+00   0.23215D+00  -0.14802D+00  -0.92477D+00  -0.12971D+01
Reaction Wheel #3 CG             58043    -0.50487D+00   0.75315D-02  -0.15131D+00  -0.97740D+00  -0.11961D+01   0.24240D+01

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.17441D-01  -0.15426D-01   0.30866D-01   0.20989D-01  -0.70829D-02   0.37223D-02
Inertial Attitude Sensors        31001     0.17441D-01  -0.15426D-01   0.30866D-01   0.20989D-01  -0.70829D-02   0.37223D-02
Inertial Attitude Sensors        31001     0.17441D-01  -0.15426D-01   0.30866D-01   0.20989D-01  -0.70829D-02   0.37223D-02
Inertial Attitude Sensors        31001     0.17441D-01  -0.15426D-01   0.30866D-01   0.20989D-01  -0.70829D-02   0.37223D-02
Inertial Attitude Sensors        31001     0.17441D-01  -0.15426D-01   0.30866D-01   0.20989D-01  -0.70829D-02   0.37223D-02
Inertial Attitude Sensors        31001     0.17441D-01  -0.15426D-01   0.30866D-01   0.20989D-01  -0.70829D-02   0.37223D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.22136D-01  -0.78093D-02   0.43186D-01
Accelerometers                   31002     0.22136D-01  -0.78093D-02   0.43186D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.79598D+00  -0.42807D-01  -0.80646D+00   0.24878D+00  -0.11432D+01   0.49640D-01

MODE# 51/ 77, Frequency (rad/sec), Damping (zeta), Generalized Mass=    635.94       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.27005D+00  -0.27016D+00  -0.30632D+00   0.10083D+01  -0.70338D+00   0.16457D+01
Reaction Wheel #2 CG             58042    -0.20183D+00  -0.24615D+00   0.22205D+00  -0.58880D-01  -0.10529D+01  -0.14836D+01
Reaction Wheel #3 CG             58043    -0.12969D+00  -0.25760D-01  -0.64328D-01  -0.26388D+00  -0.17452D+00   0.42307D+00

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.97414D-02   0.80793D-02   0.42836D-01   0.30473D-01   0.37633D-01   0.11009D-01
Inertial Attitude Sensors        31001     0.97414D-02   0.80793D-02   0.42836D-01   0.30473D-01   0.37633D-01   0.11009D-01
Inertial Attitude Sensors        31001     0.97414D-02   0.80793D-02   0.42836D-01   0.30473D-01   0.37633D-01   0.11009D-01
Inertial Attitude Sensors        31001     0.97414D-02   0.80793D-02   0.42836D-01   0.30473D-01   0.37633D-01   0.11009D-01
Inertial Attitude Sensors        31001     0.97414D-02   0.80793D-02   0.42836D-01   0.30473D-01   0.37633D-01   0.11009D-01
Inertial Attitude Sensors        31001     0.97414D-02   0.80793D-02   0.42836D-01   0.30473D-01   0.37633D-01   0.11009D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.28140D-02   0.27789D-01   0.74573D-02
Accelerometers                   31002     0.28140D-02   0.27789D-01   0.74573D-02

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.41148D+00   0.43499D-01  -0.43376D+00  -0.15649D-01  -0.61574D+00  -0.11038D+00

MODE# 52/ 78, Frequency (rad/sec), Damping (zeta), Generalized Mass=    647.55       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.40271D+00  -0.42379D+00  -0.43750D+00   0.15864D+01  -0.91822D+00   0.26130D+01
Reaction Wheel #2 CG             58042    -0.27776D+00  -0.58305D+00   0.48753D+00  -0.49346D-01  -0.27420D+01  -0.36932D+01
Reaction Wheel #3 CG             58043     0.46940D+00  -0.38360D-01   0.17478D+00   0.13168D+01   0.14047D+01  -0.29887D+01

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.89530D-02  -0.41146D-02   0.22813D-03   0.63763D-02  -0.12353D-01   0.36426D-01
Inertial Attitude Sensors        31001     0.89530D-02  -0.41146D-02   0.22813D-03   0.63763D-02  -0.12353D-01   0.36426D-01
Inertial Attitude Sensors        31001     0.89530D-02  -0.41146D-02   0.22813D-03   0.63763D-02  -0.12353D-01   0.36426D-01
Inertial Attitude Sensors        31001     0.89530D-02  -0.41146D-02   0.22813D-03   0.63763D-02  -0.12353D-01   0.36426D-01
Inertial Attitude Sensors        31001     0.89530D-02  -0.41146D-02   0.22813D-03   0.63763D-02  -0.12353D-01   0.36426D-01
Inertial Attitude Sensors        31001     0.89530D-02  -0.41146D-02   0.22813D-03   0.63763D-02  -0.12353D-01   0.36426D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.13296D-01   0.31586D-01   0.22162D-01
Accelerometers                   31002    -0.13296D-01   0.31586D-01   0.22162D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.14497D+00   0.20218D+00  -0.20295D+00  -0.49609D+00  -0.28676D+00  -0.40399D+00

MODE# 53/ 79, Frequency (rad/sec), Damping (zeta), Generalized Mass=    651.44       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.33210D+00   0.34662D+00   0.24154D+00  -0.10340D+01   0.55445D+00  -0.15550D+01
Reaction Wheel #2 CG             58042    -0.17203D+00  -0.46449D+00   0.46155D+00  -0.40241D+00  -0.21199D+01  -0.26290D+01
Reaction Wheel #3 CG             58043    -0.12926D+01  -0.20353D+00  -0.10532D+01  -0.34560D+01  -0.15606D+01   0.52278D+01

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.31041D-01  -0.18919D-02  -0.47452D-01  -0.18476D-01  -0.11642D-01   0.24184D-01
Inertial Attitude Sensors        31001     0.31041D-01  -0.18919D-02  -0.47452D-01  -0.18476D-01  -0.11642D-01   0.24184D-01
Inertial Attitude Sensors        31001     0.31041D-01  -0.18919D-02  -0.47452D-01  -0.18476D-01  -0.11642D-01   0.24184D-01
Inertial Attitude Sensors        31001     0.31041D-01  -0.18919D-02  -0.47452D-01  -0.18476D-01  -0.11642D-01   0.24184D-01
Inertial Attitude Sensors        31001     0.31041D-01  -0.18919D-02  -0.47452D-01  -0.18476D-01  -0.11642D-01   0.24184D-01
Inertial Attitude Sensors        31001     0.31041D-01  -0.18919D-02  -0.47452D-01  -0.18476D-01  -0.11642D-01   0.24184D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.14410D-01   0.18922D-01  -0.34252D-01
Accelerometers                   31002     0.14410D-01   0.18922D-01  -0.34252D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.60305D+00   0.18972D+00   0.59149D+00  -0.28279D+00   0.88801D+00  -0.37121D+00

MODE# 54/ 82, Frequency (rad/sec), Damping (zeta), Generalized Mass=    662.07       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.91368D-01  -0.69757D-01  -0.34757D+00   0.19010D+00  -0.72778D+00   0.40271D+00
Reaction Wheel #2 CG             58042    -0.18213D-01  -0.15418D+00   0.24802D+00  -0.48200D+00  -0.47274D+00  -0.11048D+00
Reaction Wheel #3 CG             58043     0.35541D-01  -0.51050D-02   0.76130D-01   0.70841D+00   0.60930D+00  -0.14303D+01

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.74237D-01   0.89615D-01   0.46791D-01   0.30262D-01   0.69313D-01  -0.55633D-01
Inertial Attitude Sensors        31001     0.74237D-01   0.89615D-01   0.46791D-01   0.30262D-01   0.69313D-01  -0.55633D-01
Inertial Attitude Sensors        31001     0.74237D-01   0.89615D-01   0.46791D-01   0.30262D-01   0.69313D-01  -0.55633D-01
Inertial Attitude Sensors        31001     0.74237D-01   0.89615D-01   0.46791D-01   0.30262D-01   0.69313D-01  -0.55633D-01
Inertial Attitude Sensors        31001     0.74237D-01   0.89615D-01   0.46791D-01   0.30262D-01   0.69313D-01  -0.55633D-01
Inertial Attitude Sensors        31001     0.74237D-01   0.89615D-01   0.46791D-01   0.30262D-01   0.69313D-01  -0.55633D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.11721D+00   0.28458D-01  -0.19285D-01
Accelerometers                   31002     0.11721D+00   0.28458D-01  -0.19285D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.83451D-02   0.44571D-01   0.12568D+00  -0.21314D+00   0.22214D+00  -0.68452D-02

MODE# 55/ 83, Frequency (rad/sec), Damping (zeta), Generalized Mass=    665.48       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.49421D-01  -0.84158D-01  -0.14134D+00   0.11851D+00  -0.28183D+00   0.16892D+00
Reaction Wheel #2 CG             58042    -0.10721D-01  -0.44467D-01  -0.21745D-01   0.26269D-01   0.36082D-01   0.11072D+00
Reaction Wheel #3 CG             58043    -0.11128D-01  -0.15780D-01   0.72556D-01   0.27852D+00   0.87679D-02  -0.21806D+00

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.32674D-01   0.16404D-01  -0.66114D-03  -0.22033D-01   0.18925D-01  -0.26725D-01
Inertial Attitude Sensors        31001     0.32674D-01   0.16404D-01  -0.66114D-03  -0.22033D-01   0.18925D-01  -0.26725D-01
Inertial Attitude Sensors        31001     0.32674D-01   0.16404D-01  -0.66114D-03  -0.22033D-01   0.18925D-01  -0.26725D-01
Inertial Attitude Sensors        31001     0.32674D-01   0.16404D-01  -0.66114D-03  -0.22033D-01   0.18925D-01  -0.26725D-01
Inertial Attitude Sensors        31001     0.32674D-01   0.16404D-01  -0.66114D-03  -0.22033D-01   0.18925D-01  -0.26725D-01
Inertial Attitude Sensors        31001     0.32674D-01   0.16404D-01  -0.66114D-03  -0.22033D-01   0.18925D-01  -0.26725D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.49855D-01  -0.11085D-01  -0.35258D-01
Accelerometers                   31002     0.49855D-01  -0.11085D-01  -0.35258D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.10245D+00  -0.11550D+00   0.15916D+00   0.88615D-01   0.23028D+00   0.30971D+00

MODE# 56/ 84, Frequency (rad/sec), Damping (zeta), Generalized Mass=    669.00       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.62088D-01  -0.68273D-01   0.11445D+00   0.23947D+00   0.29758D+00   0.34694D+00
Reaction Wheel #2 CG             58042     0.17631D-01  -0.16090D+00   0.41201D-01   0.18136D+00  -0.74941D+00  -0.11004D+01
Reaction Wheel #3 CG             58043    -0.21647D+00  -0.57430D-01  -0.23716D+00  -0.83893D+00  -0.40412D+00   0.13417D+01

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001    -0.63131D-01   0.11765D+00  -0.27692D-01  -0.45332D-01  -0.15528D-01  -0.94817D-01
Inertial Attitude Sensors        31001    -0.63131D-01   0.11765D+00  -0.27692D-01  -0.45332D-01  -0.15528D-01  -0.94817D-01
Inertial Attitude Sensors        31001    -0.63131D-01   0.11765D+00  -0.27692D-01  -0.45332D-01  -0.15528D-01  -0.94817D-01
Inertial Attitude Sensors        31001    -0.63131D-01   0.11765D+00  -0.27692D-01  -0.45332D-01  -0.15528D-01  -0.94817D-01
Inertial Attitude Sensors        31001    -0.63131D-01   0.11765D+00  -0.27692D-01  -0.45332D-01  -0.15528D-01  -0.94817D-01
Inertial Attitude Sensors        31001    -0.63131D-01   0.11765D+00  -0.27692D-01  -0.45332D-01  -0.15528D-01  -0.94817D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.12954D-01   0.60362D-02  -0.27761D-01
Accelerometers                   31002    -0.12954D-01   0.60362D-02  -0.27761D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008     0.44175D+00  -0.63066D+00   0.33822D+00   0.85778D+00   0.50092D+00   0.15280D+01

MODE# 57/ 87, Frequency (rad/sec), Damping (zeta), Generalized Mass=    679.93       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.21946D+00   0.79866D-01   0.41030D-01  -0.26808D+00   0.18310D-01  -0.37136D+00
Reaction Wheel #2 CG             58042     0.55246D-01  -0.17642D+00   0.26610D+00  -0.60137D+00  -0.15926D+00   0.28750D+00
Reaction Wheel #3 CG             58043     0.18165D+00   0.16266D+00   0.25102D+00   0.88132D+00   0.29231D+00  -0.11833D+01

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.60986D-01  -0.10434D-01  -0.33740D-01  -0.63522D-02   0.48637D-01   0.22447D-01
Inertial Attitude Sensors        31001     0.60986D-01  -0.10434D-01  -0.33740D-01  -0.63522D-02   0.48637D-01   0.22447D-01
Inertial Attitude Sensors        31001     0.60986D-01  -0.10434D-01  -0.33740D-01  -0.63522D-02   0.48637D-01   0.22447D-01
Inertial Attitude Sensors        31001     0.60986D-01  -0.10434D-01  -0.33740D-01  -0.63522D-02   0.48637D-01   0.22447D-01
Inertial Attitude Sensors        31001     0.60986D-01  -0.10434D-01  -0.33740D-01  -0.63522D-02   0.48637D-01   0.22447D-01
Inertial Attitude Sensors        31001     0.60986D-01  -0.10434D-01  -0.33740D-01  -0.63522D-02   0.48637D-01   0.22447D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.48085D-01   0.12056D-01  -0.82126D-01
Accelerometers                   31002     0.48085D-01   0.12056D-01  -0.82126D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.20997D+00   0.23620D+00  -0.21664D+00  -0.34967D+00  -0.27953D+00  -0.54180D+00

MODE# 58/ 89, Frequency (rad/sec), Damping (zeta), Generalized Mass=    693.45       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041     0.17633D-01  -0.58856D-01   0.24744D-01  -0.42241D+00   0.29959D-01  -0.77390D+00
Reaction Wheel #2 CG             58042    -0.94558D-02  -0.54903D-01  -0.18676D+00   0.35369D+00   0.91870D+00   0.88490D+00
Reaction Wheel #3 CG             58043    -0.82915D-02  -0.11362D+00   0.18321D+00   0.28886D+00  -0.56150D+00   0.49388D+00

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.18607D-01  -0.64060D-01  -0.39000D-01  -0.78710D-01  -0.23094D-01   0.41234D-01
Inertial Attitude Sensors        31001     0.18607D-01  -0.64060D-01  -0.39000D-01  -0.78710D-01  -0.23094D-01   0.41234D-01
Inertial Attitude Sensors        31001     0.18607D-01  -0.64060D-01  -0.39000D-01  -0.78710D-01  -0.23094D-01   0.41234D-01
Inertial Attitude Sensors        31001     0.18607D-01  -0.64060D-01  -0.39000D-01  -0.78710D-01  -0.23094D-01   0.41234D-01
Inertial Attitude Sensors        31001     0.18607D-01  -0.64060D-01  -0.39000D-01  -0.78710D-01  -0.23094D-01   0.41234D-01
Inertial Attitude Sensors        31001     0.18607D-01  -0.64060D-01  -0.39000D-01  -0.78710D-01  -0.23094D-01   0.41234D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002    -0.13191D-01  -0.16073D-01  -0.47963D-01
Accelerometers                   31002    -0.13191D-01  -0.16073D-01  -0.47963D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.98773D-01   0.32139D+00  -0.17696D-02  -0.51229D+00  -0.63400D-01  -0.84810D+00

MODE# 59/ 94, Frequency (rad/sec), Damping (zeta), Generalized Mass=    729.48       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.44048D-01  -0.78217D-01  -0.16594D-01   0.11303D+00  -0.11640D+00  -0.34904D-01
Reaction Wheel #2 CG             58042    -0.38055D-01  -0.10421D+00  -0.10417D+00   0.21180D+00   0.53237D+00   0.51970D+00
Reaction Wheel #3 CG             58043    -0.48141D-01  -0.13303D+00   0.11141D+00   0.25849D+00  -0.41036D+00   0.29218D+00

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.59472D-01  -0.74186D-01  -0.10902D+00  -0.16698D+00  -0.61092D-01   0.33378D-01
Inertial Attitude Sensors        31001     0.59472D-01  -0.74186D-01  -0.10902D+00  -0.16698D+00  -0.61092D-01   0.33378D-01
Inertial Attitude Sensors        31001     0.59472D-01  -0.74186D-01  -0.10902D+00  -0.16698D+00  -0.61092D-01   0.33378D-01
Inertial Attitude Sensors        31001     0.59472D-01  -0.74186D-01  -0.10902D+00  -0.16698D+00  -0.61092D-01   0.33378D-01
Inertial Attitude Sensors        31001     0.59472D-01  -0.74186D-01  -0.10902D+00  -0.16698D+00  -0.61092D-01   0.33378D-01
Inertial Attitude Sensors        31001     0.59472D-01  -0.74186D-01  -0.10902D+00  -0.16698D+00  -0.61092D-01   0.33378D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.27051D-01  -0.41755D-01  -0.10841D+00
Accelerometers                   31002     0.27051D-01  -0.41755D-01  -0.10841D+00

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.19366D+00  -0.31811D+00  -0.19930D+00   0.80881D+00  -0.25868D+00   0.79105D+00

MODE# 60/ 95, Frequency (rad/sec), Damping (zeta), Generalized Mass=    740.88       0.50000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  3 Reaction Wheels...
Reaction Wheel #1 CG             58041    -0.38234D-01   0.54279D-02  -0.12327D-01   0.15698D+00  -0.54276D-01   0.16211D+00
Reaction Wheel #2 CG             58042     0.23872D-02  -0.32136D-01   0.14296D-01  -0.73282D-01   0.71947D-01   0.14665D+00
Reaction Wheel #3 CG             58043    -0.41638D-01  -0.34842D-01  -0.32082D-01  -0.92395D-01  -0.95136D-01   0.15960D+00

                              Node ID#     Modal Data at the  6 Gyros ...
Inertial Attitude Sensors        31001     0.20068D-01  -0.41742D-01  -0.56465D-01  -0.56683D-01  -0.42977D-01   0.17095D-01
Inertial Attitude Sensors        31001     0.20068D-01  -0.41742D-01  -0.56465D-01  -0.56683D-01  -0.42977D-01   0.17095D-01
Inertial Attitude Sensors        31001     0.20068D-01  -0.41742D-01  -0.56465D-01  -0.56683D-01  -0.42977D-01   0.17095D-01
Inertial Attitude Sensors        31001     0.20068D-01  -0.41742D-01  -0.56465D-01  -0.56683D-01  -0.42977D-01   0.17095D-01
Inertial Attitude Sensors        31001     0.20068D-01  -0.41742D-01  -0.56465D-01  -0.56683D-01  -0.42977D-01   0.17095D-01
Inertial Attitude Sensors        31001     0.20068D-01  -0.41742D-01  -0.56465D-01  -0.56683D-01  -0.42977D-01   0.17095D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
Accelerometers                   31002     0.54855D-02  -0.25231D-01  -0.31773D-01
Accelerometers                   31002     0.54855D-02  -0.25231D-01  -0.31773D-01

                              Node ID#     Modal Data at the Disturbance Point 
RCS Jet #8    (+X)               98008    -0.76304D-01  -0.42040D+00  -0.12345D+00   0.96360D+00  -0.13264D+00   0.10842D+01
---------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (TITLE, SYSTEM/MATRIX, M-FILENAME)                           
Flex Satellite with Reaction Wheels                                 
System                                                                                          
Satellite_60flx.m                                                                         
---------------------------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
