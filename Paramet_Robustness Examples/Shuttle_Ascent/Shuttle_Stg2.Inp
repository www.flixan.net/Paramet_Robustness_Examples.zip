BATCH MODE INSTRUCTIONS ...............                                                             
Batch for creating a Space Shuttle model during Second Stage
! This batch set creates Shuttle Ascent Stage-2 models for linear 
! stability and robustness analysis.
!
Flight Vehicle   : Space Shuttle Second Stage at T=123 sec
Flight Vehicle   : Space Shuttle Second Stage at T=123 sec (With Uncertain Param)
Actuator Model   : Shuttle Main Engine Hydraulic Actuator (Type-I)
System Connection: Actuators/TVC (Second Stage)  
Transf-Function  : Sensor Dynamics
System Connection: Plant Model, Vehicle/Actuators/Sensors
Transf-Function  : Shuttle Stage-2 Flight Control System
To Matlab Format : Space Shuttle Second Stage at T=123 sec
To Matlab Format : Plant Model, Vehicle/Actuators/Sensors
To Matlab Format : Actuators/TVC (Second Stage) 
To Matlab Format : Sensor Dynamics
To Matlab Format : Shuttle Stage-2 Flight Control System       
To Matlab Format : Space Shuttle Second Stage at T=123 sec (With Uncertain Param)       
----------------------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Space Shuttle Second Stage at T=123 sec
! The following represents a Space Shuttle Ascent model at T=123 sec, Second Stage, 
! immediately after SRB separation. It uses only the three main engines.
Body Axes Output,Attitude=Rate Integral,Without GAFD, No Turn Coordination  
  
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :  0.418209E+05 32.1          0.20896E+08
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :  0.604722E+7  0.873354E+8   0.829562E+8  0.648080E+5  0.140521E+8  0.199420E+5   
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        : -95.194       0.0619       -38.847
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :  4.25         4600.0        55.37        0.153155E+06    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :  28.77        28.87         0.14         8.484
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  2.78         0.1           0.0          0.0    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   : -178.6        26.3          90.4         0.043        0.2825      -0.026
Wind Gust Velocity, Wind Direction to Vehicle Defined by Azimuth and Elevat Angles (deg) :  Gust         45.0          90.0    
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :  2690.0       39.56         78.05   
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} : -95.194       0.0619       -38.847       0.0000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.1435       0.00314159    0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}: -0.003       -0.031765      0.0000      -0.0022       0.0000       0.0000       0.0000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:  0.013       -0.0292866     0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}: -0.00173     -0.0045125     0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  0.05586     -0.0148456     0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:  0.00152      0.00867568    0.0000       0.0000       0.0000       0.0000    

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  0   NO TWD  

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  3   WITH TWD  

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : SSME Top-Cent   Gimbaling only
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  488688.0      488688.0  
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -14.0          0.0          10.0         10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  210.0         4032.0       3.0  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -182.16        0.0         -64.94    
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : SSME Left       Gimbaling only
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  488688.0      488688.0  
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -10.8          3.5          10.0         10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  210.0         4032.0       3.0  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -184.1        -4.4         -56.33   
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : SSME Right      Gimbaling only
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  488688.0      488688.0  
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -10.8         -3.5          10.0         10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  210.0         4032.0       3.0  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -184.1        +4.4         -56.33    

Number of Gyros, (Attitude and Rate)                                                     :  3
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Roll   Rate          -93.62    0.0   -61.53               
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Pitch  Rate          -93.62    0.0   -61.53                
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Yaw    Rate          -93.62    0.0   -61.53                 

Number of Accelerometers, Along Axis: (x,y,z)                                            :  2
Acceleromet No  1 Axis:(X,Y,Z), (Z Acceleration, Flex and Rigid),   (N2311)              :  Z-axis Accelerat.    -93.62    0.0   -61.53             
Acceleromet No  2 Axis:(X,Y,Z), (Y Acceleration, Flex and Rigid),   (N2311)              :  Y-axis Accelerat.    -93.62    0.0   -61.53             

Number of Slosh Modes                                                                    :  2
LOX Slosh Mass (slugs), Frequ Wy,Wz 1g (rad/s), Damp (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft):  6024.4  2.215  2.215  0.003  0.003  -64.672   0.0  -33.33    
LH2 Slosh Mass (slugs), Frequ Wy,Wz 1g (rad/s), Damp (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft):  511.06  2.102  2.102  0.005  0.005  -125.338  0.0  -33.33      

Number of Bending Modes                                                                  : 20
Shuttle Second Stage at T=123 sec, Mixed Modes                                  
--------------------------------------------------------------------------------------------------------------------------------------------------------                                                                  
FLIGHT VEHICLE INPUT DATA ......
Space Shuttle Second Stage at T=123 sec (With Uncertain Param)
! The following represents a Space Shuttle Ascent model at T=123 sec, Second Stage, 
! immediately after SRB separation. It uses also uncertain parameters data for
! Robustness Analysis
Body Axes Output,Attitude=Rate Integral,Without GAFD, No Turn Coordination  
  
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :  0.418209E+05 32.1          0.20896E+08
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :  0.604722E+7  0.873354E+8   0.829562E+8  0.648080E+5  0.140521E+8  0.199420E+5   
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        : -95.194       0.0619       -38.847
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :  4.25         4600.0        55.37        0.153155E+06    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :  28.77        28.87         0.14         8.484
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  2.78         0.1           0.0          0.0    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   : -178.6        26.3          90.4         0.043        0.2825      -0.026
Wind Gust Vel wrt Vehicle (Azim & Elev) angles, or Force (lb), location, Torque (ft-lb)  :  Gust         45.0          90.0    
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :  2690.0       39.56         78.05   
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} : -95.194       0.0619       -38.847       0.0000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.1435       0.00314159    0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}: -0.003       -0.031765      0.0000      -0.0022       0.0000       0.0000       0.0000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:  0.013       -0.0292866     0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}: -0.00173     -0.0045125     0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  0.05586     -0.0148456     0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:  0.00152      0.00867568    0.0000       0.0000       0.0000       0.0000    

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  0   NO TWD  

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  3   WITH TWD  

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : SSME Top-Cent   Gimbaling only
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  488688.0      488688.0  
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -14.0          0.0          10.0         10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  210.0         4032.0       3.0  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -182.16        0.0         -64.94    
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : SSME Left       Gimbaling only
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  488688.0      488688.0  
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -10.8          3.5          10.0         10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  210.0         4032.0       3.0  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -184.1        -4.4         -56.33   
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : SSME Right      Gimbaling only
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  488688.0      488688.0  
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -10.8         -3.5          10.0         10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  210.0         4032.0       3.0  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -184.1        +4.4         -56.33    

Number of Gyros, (Attitude and Rate)                                                     :  3
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Roll   Rate          -93.62    0.0   -61.53               
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Pitch  Rate          -93.62    0.0   -61.53                
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Yaw    Rate          -93.62    0.0   -61.53                 

Number of Accelerometers, Along Axis: (x,y,z)                                            :  2
Acceleromet No  1 Axis:(X,Y,Z), (Z Acceleration, Flex and Rigid),   (N2311)              :  Z-axis Accelerat.    -93.62    0.0   -61.53             
Acceleromet No  2 Axis:(X,Y,Z), (Y Acceleration, Flex and Rigid),   (N2311)              :  Y-axis Accelerat.    -93.62    0.0   -61.53             

Number of Slosh Modes                                                                    :  2
LOX Slosh Mass (slugs), Frequ Wy,Wz 1g (rad/s), Damp (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft):  6024.4  2.215  2.215  0.003  0.003  -64.672   0.0  -33.33    
LH2 Slosh Mass (slugs), Frequ Wy,Wz 1g (rad/s), Damp (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft):  511.06  2.102  2.102  0.005  0.005  -125.338  0.0  -33.33      

Parameter Uncertainties Data
Uncertainties for Shuttle Ascent Second Stage

Number of Bending Modes                                                                  : 20
Shuttle Second Stage at T=123 sec, Mixed Modes                                  
--------------------------------------------------------------------------------------------------------------------------------------------------------                                                                  
UNCERTAIN PARAMETER VARIATIONS FROM NOMINAL ......                                                                    
Uncertainties for Shuttle Ascent Second Stage
! The following data are not actual vehicle parameters but they represent uncertainties
! of the corresponding parameters for the vehicle above. The title above these comments                                                                                
! defines the flight condition where they apply. The uncertainty values represent a +ve 
! or -ve additive variation above or below the nominal values shown in the set above.
! The uncertainties include slosh parameters and flex mode frequency variations.
                                                                                                                                                                                                                            
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :  0.0          0.0          0.0                                                                                           
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :  0.4E+6       0.3E+7       0.3E+7  0.0   0.0    0.0                                                       
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  1.0          0.0          0.0
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :  0.0          0.0          0.0          0.0                                                                                  
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :  0.0          0.0          0.0          0.0                                                                                    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  2.0          2.0          0.0          0.0                                                                        
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   : -0.0          0.0          0.0          0.0   0.0    0.0                                                       
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.02,   0.001,    0.0,   0.0,     0.0,     0.0,    0.0                                                                         
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  0.0,    0.008,    0.0,   0.0,    -0.0,     0.0,    0.0                                                                         
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:  0.03,   0.002,    0.0,   0.0,     0.0,     0.0,    0.0                                            
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:  0.0,    0.002,    0.0,   0.0,    -0.0,     0.0                                                                                 
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  0.02,   0.002,    0.0,   0.0,     0.0,     0.0,    0.0                                                                         
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:  0.0,    0.002,    0.0,   0.0,     0.0,     0.0                                                                                 
                                                                                                                                                                                                                            
Number of Control Surfaces, (Variations from Nominal Aero Parameters)                    :  0                                                          
                                                                                                                                                                                                                            
Number of Thruster Engines, (Variations from Nominal Parameters)                         :  3                                                           

TVC Engine No:  1                                                                        : Jet #1      
Engine Thrust Additive Variation,  (lb)                                                  :  10000.0     
Engine Mounting Angles Variations from Nominal Angles (Dyn,Dzn) (deg)                    :  0.0        0.0       
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  0.0        0.0     0.0           
TVC Engine No:  2                                                                        : Jet #2   
Engine Thrust Additive Variation,  (lb)                                                  :  10000.0     
Engine Mounting Angles Variations from Nominal Angles (Dyn,Dzn) (deg)                    :  0.0        0.0       
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  0.0        0.0     0.0           
TVC Engine No:  3                                                                        : Jet #3      
Engine Thrust Additive Variation,  (lb)                                                  :  10000.0     
Engine Mounting Angles Variations from Nominal Angles (Dyn,Dzn) (deg)                    : -0.0       -0.0       
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  0.0        0.0     0.0           
                                                                                                                                                                                                                                                                                                                                                                                                                                                                                                                                                                                                                                                       
Number of Slosh Modes                                                                    :  2                                                                                                                               
LOX Slosh Mass (slugs), Frequ Wy,Wz 1g (rad/s), Damp (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft):  100.0  0.05  0.05  0.00  0.00  2.0  0.0  0.5
LH2 Slosh Mass (slugs), Frequ Wy,Wz 1g (rad/s), Damp (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft):  55.0   0.05  0.05  0.00  0.00  2.0  0.0  0.5

Flex Mode Uncertainties (Mode Number)                                                    :  1      3      4      5      8      17 
Flex Mode Frequency (omega) Variation (additive)  (rad/sec)                              :  0.5    0.7    0.7    0.8    0.9    1.2
Flex Mode Damping Coefficient (zeta) Variation (additive)                                :  0.002  0.002  0.002  0.003  0.002  0.003
--------------------------------------------------------------------------------------------------------------------------------------------------------                                                                  
UNCERTAIN PARAMETER VARIATIONS FROM NOMINAL ......
Uncertainties for Shuttle Ascent Second Stage (b)
! The following represents a Space Shuttle Ascent model at T=123 sec, Second Stage, immediately    
! after SRB separation. It uses only the three main engines.                                        
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   0.00000       0.00000       0.00000    
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   400000.      0.300000E+07  0.300000E+07   0.00000       0.00000       0.00000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   1.00000      0.000000      0.000000    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   0.00000       0.00000       0.00000       0.00000    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   0.00000       0.00000       0.00000       0.00000    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   2.00000       2.00000       0.00000       0.00000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.00000       0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.200000E-01  0.100000E-02   0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.00000      0.800000E-02   0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:  0.300000E-01  0.200000E-02   0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.00000      0.200000E-02   0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  0.200000E-01  0.200000E-02   0.00000       0.00000       0.00000       0.00000       0.00000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.00000      0.200000E-02   0.00000       0.00000       0.00000       0.00000    

Number of Thruster Engines, (Variations from Nominal Parameters)                         :  3

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : SSME Top-Cent    Gimbaling             
Engine Thrust Additive Variation,  (lb)                                                  :   10000.0    
Engine Mounting Angles Variations from Nominal Angles (Dyn,Dzn) (deg)                    :   0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm: engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : SSME Left        Gimbaling             
Engine Thrust Additive Variation,  (lb)                                                  :   10000.0    
Engine Mounting Angles Variations from Nominal Angles (Dyn,Dzn) (deg)                    :   0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm: engine CG to gimbal (ft):   0.00000       0.00000       0.00000    
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : SSME Right       Gimbaling             
Engine Thrust Additive Variation,  (lb)                                                  :   10000.0    
Engine Mounting Angles Variations from Nominal Angles (Dyn,Dzn) (deg)                    :   0.00000       0.00000    
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm: engine CG to gimbal (ft):   0.00000       0.00000       0.00000    

Number of Slosh Modes (Uncertainty Data)                                                 :  2
Tank 1 Slosh Mass (slugs), Frequ Wy,Wz 1g (rad/s), Damp (zeta-y-z), SM Locat. X,Y,Z, (ft):   100.000      0.050000      0.050000       0.00000       0.00000       2.00000       0.00000       0.50000    
Tank 2 Slosh Mass (slugs), Frequ Wy,Wz 1g (rad/s), Damp (zeta-y-z), SM Locat. X,Y,Z, (ft):   55.0000      0.050000      0.050000       0.00000       0.00000       2.00000       0.00000       0.50000    
  
Flex Mode Uncertainties (Mode Number)                                                    :      1      3      4      5      8     17
Flex Mode Frequency (omega) Variation (additive)  (rad/sec)                              :  0.500  0.700  0.700  0.800  0.900  1.200
Flex Mode Damping Coefficient (zeta) Variation (additive)                                : 0.0020 0.0020 0.0020 0.0030 0.0020 0.0030
----------------------------------------------------------------------------------------------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ HYDRAULIC TYPE B
Shuttle Main Engine Hydraulic Actuator (Type-I)
! This actuator model is used for the three Shuttle main engines for 
! pitch and yaw gimbaling
Symbol       Parameter Description               (Units)     Value
C(s)   Order of Compensat:(0,1,2), Coefficients   (---)      0
Kav    Total Gain of Amplifier + Torque Motor  (ft-lb/rad)  0.91000
Kact   Power Valve and Actuator Gain .........(ft/s/ft-lb)   53.950
Kt     Piston Ram Stiffness ...................  (lb/ft)    0.20280E+07
R      Moment Arm of Actuator Ram from Gimbal    (feet)      2.4800
Ie     Engine Inertia about Gimbal ............(ft-lb-s^2)   4516.0
Be     Engine Viscous Damping .................(ft-lb-sec)   16500.
Kb     Engine Gimbal Bearing Spring Constant   (ft-lb/rad)   27160.0
Kl     Engine Mount Structural Stiffness ......  (lb/ft)    0.27960E+07
Tc     Different. Pressure Feedbk Time Constant  (seconds)  0.12660
Kdpf   Differ Pressure Feedbk Linearizat. Gain  (ft-lb/lb)  0.40400E-06
Kfb    Position Feedback Gain ................. (rad/feet)  0.4
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Actuators/TVC (Second Stage)
! The Following System Consists of Pitch and Yaw Actuators and the TVC For the 3 Engines.
! The System Inputs are the 3 flight control commands: DPTVC, DQTVC, DRTVC, the 3 
! pitch load-torques: TLY1, TLY2, TLY3, and the 3 yaw load-torques: TLZ1, TLZ2, TLZ3  
! The First 6 Outputs are Pitch and Yaw Deflections.
! The Last  6 Outputs are Pitch and Yaw Accelerations
Titles of Systems to be Combined
Title 1 Shuttle Main Engine Hydraulic Actuator (Type-I)
Title 2 Shuttle Main Engine Hydraulic Actuator (Type-I)
Title 3 Shuttle Main Engine Hydraulic Actuator (Type-I)
Title 4 Shuttle Main Engine Hydraulic Actuator (Type-I)
Title 5 Shuttle Main Engine Hydraulic Actuator (Type-I)
Title 6 Shuttle Main Engine Hydraulic Actuator (Type-I)
SYSTEM INPUTS TO SUBSYSTEM  1                                           DY1
System Input  2 to Subsystem  1, Input  1, Gain= 1.071
System Input  4 to Subsystem  1, Input  2, Gain= 1.0                    TLY1
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                           DY2
System Input  1 to Subsystem  2, Input  1, Gain= -0.45                  KLMPS
System Input  2 to Subsystem  2, Input  1, Gain= 1.071                  KMMPS
System Input  5 to Subsystem  2, Input  2, Gain= 1.0                    TLY2
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  3                                           DY3
System Input  1 to Subsystem  3, Input  1, Gain= +0.45                  KLMPS
System Input  2 to Subsystem  3, Input  1, Gain= 1.071                  KMMPS
System Input  6 to Subsystem  3, Input  2, Gain= 1.0                    TLY3
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  4                                           DZ1
System Input  1 to Subsystem  4, Input  1, Gain= -0.337                 KLMPS*0.75
System Input  3 to Subsystem  4, Input  1, Gain= 1.13                   KNMPS
System Input  7 to Subsystem  4, Input  2, Gain= 1.0                    TLZ1
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  5                                           DZ2
System Input  3 to Subsystem  5, Input  1, Gain= 1.13                   KNMPS
System Input  8 to Subsystem  5, Input  2, Gain= 1.0                    TLZ2
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  6                                           DZ3
System Input  3 to Subsystem  6, Input  1, Gain= 1.13                   KNMPS
System Input  9 to Subsystem  6, Input  2, Gain= 1.0                    TLZ3
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1
System Output  1 from Subsystem  1, Output  1, Gain= 1.0                dy1
System Output  7 from Subsystem  1, Output  3, Gain= 1.0                dy1_dd
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2
System Output  2 from Subsystem  2, Output  1, Gain= 1.0                dy2
System Output  8 from Subsystem  2, Output  3, Gain= 1.0                dy2_dd
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3
System Output  3 from Subsystem  3, Output  1, Gain= 1.0                dy3
System Output  9 from Subsystem  3, Output  3, Gain= 1.0                dy3_dd
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  4
System Output  4 from Subsystem  4, Output  1, Gain= 1.0                dz1
System Output 10 from Subsystem  4, Output  3, Gain= 1.0                dz1_dd
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  5
System Output  5 from Subsystem  5, Output  1, Gain= 1.0                dz2
System Output 11 from Subsystem  5, Output  3, Gain= 1.0                dz2_dd
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  6
System Output  6 from Subsystem  6, Output  1, Gain= 1.0                dz3
System Output 12 from Subsystem  6, Output  3, Gain= 1.0                dz3_dd
..............................................................................
Definitions of Inputs  =   9
Roll FCS Command (DPTVC)
Pitch FCS Command (DQTVC)
Yaw FCS Command (DRTVC)
Engine 1 Pitch Load-Torque TLY1
Engine 2 Pitch Load-Torque TLY2
Engine 3 Pitch Load-Torque TLY3
Engine 1 Yaw Load-Torque TLZ1
Engine 2 Yaw Load-Torque TLZ2
Engine 3 Yaw Load-Torque TLZ3

Definitions of Outputs =  12
Engine 1 Pitch Deflection (rad)
Engine 2 Pitch Deflection (rad)
Engine 3 Pitch Deflection (rad)
Engine 1 Yaw Deflection (rad)
Engine 2 Yaw Deflection (rad)
Engine 3 Yaw Deflection (rad)
Engine 1 Pitch Accelerat (rad/sec^2)
Engine 2 Pitch Accelerat (rad/sec^2)
Engine 3 Pitch Accelerat (rad/sec^2)
Engine 1 Yaw Accelerat (rad/sec^2)
Engine 2 Yaw Accelerat (rad/sec^2)
Engine 3 Yaw Accelerat (rad/sec^2)
--------------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Sensor Dynamics
! Roll, Pitch, Yaw Attitude and Rate Sensors used for Flight Control
Continuous
TF. Block #  1 Roll IMU Filter                                   Order of Numer, Denom=  1  1
Numer 0.00000     7.00000
Denom 1.00000     7.00000
TF. Block #  2 Roll Rate Gyro Filter                             Order of Numer, Denom=  1  1
Numer 0.00000     50.0000
Denom 1.00000     50.0000
TF. Block #  3 Pitch IMU Filter                                  Order of Numer, Denom=  1  1
Numer 0.00000     7.00000
Denom 1.00000     7.00000
TF. Block #  4 Pitch Rate Gyro Filter                            Order of Numer, Denom=  1  1
Numer 0.00000     50.0000
Denom 1.00000     50.0000
TF. Block #  5 Yaw IMU Filter                                    Order of Numer, Denom=  1  1
Numer 0.00000     7.00000
Denom 1.00000     7.00000
TF. Block #  6 Yaw Rate Gyro Filter                              Order of Numer, Denom=  1  1
Numer 0.00000     50.0000
Denom 1.00000     50.0000
------------------------------------------------------------------------------
Block #, from Input #, Gain:
   1     1     1.0
   2     2     1.0
   3     3     1.0
   4     4     1.0
   5     5     1.0
   6     6     1.0
...........................
Outpt #, from Block #, Gain:
   1     1     1.0
   2     2     1.0
   3     3     1.0
   4     4     1.0
   5     5     1.0
   6     6     1.0
...........................
Definitions of Inputs  =   6
Roll Attitude from Vehicle                                                                
Roll Rate from Vehicle                                                                
Pitch Attitude from Vehicle                                                                
Pitch Rate from Vehicle                                                                
Yaw Attitude from Vehicle                                                                
Yaw Rate from Vehicle                                                                
 
Definitions of Outputs =   6
Roll Attitude to FCS
Roll Rate to FCS
Pitch Attitude to FCS
Pitch Rate to FCS
Yaw Attitude to FCS
Yaw Rate to FCS
--------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....                                                       Comments
Plant Model, Vehicle/Actuators/Sensors 
! Combined Model of Vehicle, Actuators, TVC, and Sensor dynamics
Titles of Systems to be Combined
Title 1 Actuators/TVC (Second Stage)
Title 2 Space Shuttle Second Stage at T=123 sec
Title 3 Sensor Dynamics
SYSTEM INPUTS TO SUBSYSTEM  1                                                          Actuator
System Input  1 to Subsystem  1, Input  1, Gain= 1.0                                   DP_tvc
System Input  2 to Subsystem  1, Input  2, Gain= 1.0                                   DQ_tvc
System Input  3 to Subsystem  1, Input  3, Gain= 1.0                                   DR_tvc
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                                          Vehicle
System Input  4 to Subsystem  2, Input 13, Gain= 1.0                                   V-Gust
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3                                                       Sensors (IMU, Gyros)
Via Matrix +I6
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                       Vehicle
System Output  7 from Subsystem  2, Output  7, Gain= 1.0                               alfa
System Output  8 from Subsystem  2, Output  8, Gain= 1.0                               beta
System Output  9 from Subsystem  2, Output 15, Gain= 1.0                               Nz
System Output 10 from Subsystem  2, Output 16, Gain= 1.0                               Ny
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                                Actuat to Vehicle
Subsystem  1, Output  1 to Subsystem  2, Input  1, Gain= 1.0                           dy1
Subsystem  1, Output  2 to Subsystem  2, Input  2, Gain= 1.0                           dy2
Subsystem  1, Output  3 to Subsystem  2, Input  3, Gain= 1.0                           dy3
Subsystem  1, Output  7 to Subsystem  2, Input  4, Gain= 1.0                           dy1_dd
Subsystem  1, Output  8 to Subsystem  2, Input  5, Gain= 1.0                           dy2_dd
Subsystem  1, Output  9 to Subsystem  2, Input  6, Gain= 1.0                           dy3_dd
Subsystem  1, Output  4 to Subsystem  2, Input  7, Gain= 1.0                           dz1
Subsystem  1, Output  5 to Subsystem  2, Input  8, Gain= 1.0                           dz2
Subsystem  1, Output  6 to Subsystem  2, Input  9, Gain= 1.0                           dz3
Subsystem  1, Output 10 to Subsystem  2, Input 10, Gain= 1.0                           dz1_dd
Subsystem  1, Output 11 to Subsystem  2, Input 11, Gain= 1.0                           dz2_dd
Subsystem  1, Output 12 to Subsystem  2, Input 12, Gain= 1.0                           dz3_dd
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  3                                                Vehicle to Sensors
Subsystem  2, Output  1 to Subsystem  3, Input  1, Gain= 1.0                           phi
Subsystem  2, Output  3 to Subsystem  3, Input  3, Gain= 1.0                           theta
Subsystem  2, Output  5 to Subsystem  3, Input  5, Gain= 1.0                           psi
Subsystem  2, Output 12 to Subsystem  3, Input  2, Gain= 1.0                           p-flex
Subsystem  2, Output 13 to Subsystem  3, Input  4, Gain= 1.0                           q-flex
Subsystem  2, Output 14 to Subsystem  3, Input  6, Gain= 1.0                           r-flex
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  1                                                Vehicle to Actuator (Eng Load-Torque)
Subsystem  2, Output 17 to Subsystem  1, Input  4, Gain= 1.0                           TLY-1
Subsystem  2, Output 18 to Subsystem  1, Input  5, Gain= 1.0                           TLY-2
Subsystem  2, Output 19 to Subsystem  1, Input  6, Gain= 1.0                           TLY-3
Subsystem  2, Output 20 to Subsystem  1, Input  7, Gain= 1.0                           TLZ-1
Subsystem  2, Output 21 to Subsystem  1, Input  8, Gain= 1.0                           TLZ-2
Subsystem  2, Output 22 to Subsystem  1, Input  9, Gain= 1.0                           TLZ-3
..............................................................................
Definitions of Inputs  =   4
Roll FCS Command (DP-TVC)
Pitch FCS Command (DQ-TVC)
Yaw FCS Command (DR-TVC)
Wind-Gust Velocity (ft/sec)
 
Definitions of Outputs =  10
Roll Attitude to FCS
Roll Rate to FCS
Pitch Attitude to FCS
Pitch Rate to FCS
Yaw Attitude to FCS
Yaw Rate to FCS
Angle of Attack, alpha (rad)
Angle of Sideslip, beta (rad)
Normal Accelerometer, Nz (ft/sec^2)
Lateral Accelerometer, Ny (ft/sec^2)
--------------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Shuttle Stage-2 Flight Control System
! The Following System is a Pitch and Lateral Combined flight
! control system of the Space Shuttle during Second Stage of Ascent
Continuous
TF. Block #  1 MQO-(A)                                           Order of Numer, Denom=  2  2
Numer 0.3481644   3.4805598   171.3888                                                       
Denom 1.0000000   12.643319   171.3888                                                       
TF. Block #  2 MQO-(B)                                           Order of Numer, Denom=  2  2
Numer 0.5192794   3.0         204.25                                                       
Denom 1.00000     13.708      204.25                                                       
TF. Block #  3 MLLS2                                             Order of Numer, Denom=  2  2
Numer 1.13860     16.149246   108.0641                                                       
Denom 1.00000     8.116       108.0641                                               
TF. Block #  4 MRO                                               Order of Numer, Denom=  2  2
Numer 0.1503906   6.05162484  99.21824
Denom 1.00000     11.7500907  99.21824
TF. Block #  5 Pitch Integrator                                  Order of Numer, Denom=  0  1
Numer 0.0         1.0
Denom 1.00000     0.0
TF. Block #  6 Yaw Integrator                                    Order of Numer, Denom=  0  1
Numer 0.0         1.0
Denom 1.00000     0.0
TF. Block #  7 NRO-(a)                                           Order of Numer, Denom=  2  2
Numer 0.25        2.33655      98.65377
Denom 1.00000     9.73662      98.65377
TF. Block #  8 NRO-(b)                                           Order of Numer, Denom=  2  2
Numer 0.574359    6.647751     378.0831
Denom 1.00000     17.978       378.0831
TF. Block #  9 NLLB                                              Order of Numer, Denom=  2  2
Numer 1.124138    25.628049    220.838
Denom 1.00000     17.1568      220.838
TF. Block # 10 NROFF                                             Order of Numer, Denom=  2  2
Numer 0.3397436   9.9372198    378.0826
Denom 1.00000     17.978       378.0826
TF. Block # 11 Roll Integrator                                   Order of Numer, Denom=  0  1
Numer 0.0         1.0
Denom 1.00000     0.0
TF. Block # 12 LPBC-(A)                                          Order of Numer, Denom=  2  2
Numer 0.5477522   10.34161     215.6798
Denom 1.00000     22.617       215.6798
TF. Block # 13 LPBC-(B)                                          Order of Numer, Denom=  2  2
Numer 0.4923835   5.536643     263.2319
Denom 1.00000     5.61568      263.2319
TF. Block # 14 LRO                                               Order of Numer, Denom=  2  2
Numer 0.3573574   20.478539    588.7849
Denom 1.00000     26.149       588.7849
-------------------------------------------------------------------------------
Block #, from Input #, Gain
  5      2      0.4                                             the-error (KM_theta)
  1      2      0.4                                             the-error (KM_theta)
  1      5      1.0                                             q-error
  6      3      0.5                                             psi-error (KN_psi)
  7      3      0.5                                                       (KN_psi)
  7      6      1.0                                             yaw rate (r.gyro)
 11      3     -0.0                                             psi_error (KL_psi)
 11      1      0.5                                             phi-error (KL_phi)
 12      3     -0.0                                             psi_error (KL_psi)
 12      1      0.5                                             phi-error (KL_phi)
 12      4      1.0                                             p_orb
...........................
Block #, from Block #, Gain
  2      1      1.0                                             MQO (1 & 2)
  3      2      1.0                                             MLLS2
  4      3      1.0                                             MRO
  8      7      1.0                                             NRO (1 & 2)
  9      8      1.0                                             NLLB
 10      9      1.0                                             NROFF
 12     11      0.075                                           LPBC (1) * kl_int
 13     12      1.0                                             LPBC (2)
 14     13      1.0                                             LRO
...........................
Outpt #, from Block #, Gain
  1     10      1.6                                             P-TVC  KL_delpsi
  1     14      1.0
  2      5      0.106                                           Q-TVC  KM_int/KM_mps
  2      4      1.00000
  3      6      0.075                                           R-TVC  KN_int/KN_mps=0.075
  3     10      1.00000
...........................
Definitions of Inputs  =   6
Roll Attitude Error  (phi-err)
Pitch Attitude Error (theta-err)
Yaw Attitude Error   (psi-err)
Roll Rate Error  (p-err)
Pitch Rate Error (q-err)
Yaw Rate Error   (r-err)
 
Definitions of Outputs =   3
Roll FCS (DP-TVC)
Pitch FCS (DQ-TVC)
Yaw FCS (DR-TVC)
--------------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS USING MULTIPLE CRITERIA         
Shuttle Second Stage at T=123 sec, Mixed Modes                                  

MODE # 1/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    9.0752       0.20000E-01    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077     0.15362D+00   0.12782D-02  -0.24250D+00   0.69584D-04  -0.89453D-02   0.69186D-04
Shuttle Main Engine # 2           2243     0.79232D-01   0.13871D-02  -0.25930D+00  -0.43284D-04  -0.88351D-02  -0.11605D-03
Shuttle Main Engine # 3           2080     0.79451D-01   0.12117D-02  -0.26014D+00   0.79560D-04  -0.97774D-02   0.10219D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168     0.44584D-01   0.00000D+00   0.00000D+00   0.24427D-03  -0.10604D-01  -0.32453D-03
Aft Payload Gyro (left)           2168     0.44584D-01   0.00000D+00   0.00000D+00   0.24427D-03  -0.10604D-01  -0.32453D-03
Aft Payload Gyro (left)           2168     0.44584D-01   0.00000D+00   0.00000D+00   0.24427D-03  -0.10604D-01  -0.32453D-03

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.12908D-02  -0.98519D-02
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.12908D-02  -0.98519D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00  -0.23727D-03  -0.32455D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.38542D-03  -0.79081D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077     0.15362D+00   0.12782D-02  -0.24250D+00   0.69584D-04  -0.89453D-02   0.69186D-04

MODE # 2/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    9.4117       0.10000E-01    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077    -0.69673D-03  -0.11869D+00   0.21129D-02  -0.35287D-02   0.78575D-04   0.29990D-03
Shuttle Main Engine # 2           2243     0.34073D-03  -0.89213D-01   0.17570D-01  -0.35216D-02  -0.21202D-04   0.15974D-03
Shuttle Main Engine # 3           2080    -0.12625D-02  -0.89319D-01  -0.13351D-01  -0.34372D-02  -0.68072D-04   0.27203D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168     0.11844D-03   0.00000D+00   0.00000D+00  -0.33881D-02   0.61501D-04   0.38185D-03
Aft Payload Gyro (left)           2168     0.11844D-03   0.00000D+00   0.00000D+00  -0.33881D-02   0.61501D-04   0.38185D-03
Aft Payload Gyro (left)           2168     0.11844D-03   0.00000D+00   0.00000D+00  -0.33881D-02   0.61501D-04   0.38185D-03

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.10966D+00  -0.25398D-02
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.10966D+00  -0.25398D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00  -0.15104D-02   0.58053D-04   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.21983D-02   0.91942D-03   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077    -0.69673D-03  -0.11869D+00   0.21129D-02  -0.35287D-02   0.78575D-04   0.29990D-03

MODE # 3/ 11, Frequency (rad/sec), Damping (zeta), Generalized Mass=    9.7279       0.10000E-01    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077    -0.12018D+00   0.46434D-03   0.14967D+00   0.23965D-04   0.72390D-02  -0.56797D-04
Shuttle Main Engine # 2           2243    -0.59898D-01  -0.27628D-03   0.16302D+00   0.97674D-04   0.71726D-02   0.91382D-04
Shuttle Main Engine # 3           2080    -0.60111D-01  -0.13282D-03   0.16433D+00   0.98057D-05   0.79316D-02  -0.74923D-04

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.31995D-01   0.00000D+00   0.00000D+00  -0.12730D-03   0.87233D-02   0.28919D-03
Aft Payload Gyro (left)           2168    -0.31995D-01   0.00000D+00   0.00000D+00  -0.12730D-03   0.87233D-02   0.28919D-03
Aft Payload Gyro (left)           2168    -0.31995D-01   0.00000D+00   0.00000D+00  -0.12730D-03   0.87233D-02   0.28919D-03

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.13705D-02  -0.96822D-02
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.13705D-02  -0.96822D-02

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00   0.23307D-03   0.27561D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.55937D-03   0.34758D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077    -0.12018D+00   0.46434D-03   0.14967D+00   0.23965D-04   0.72390D-02  -0.56797D-04

MODE # 4/ 12, Frequency (rad/sec), Damping (zeta), Generalized Mass=    15.901       0.20000E-01    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077     0.38457D-03  -0.11604D+01  -0.39839D-03  -0.31801D-01   0.61663D-03  -0.40313D-02
Shuttle Main Engine # 2           2243     0.93614D-02  -0.91147D+00   0.15036D+00  -0.34255D-01   0.23797D-02   0.21961D-02
Shuttle Main Engine # 3           2080    -0.16042D-01  -0.91461D+00  -0.15274D+00  -0.31852D-01  -0.34620D-02   0.54964D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168     0.88318D-02   0.00000D+00   0.00000D+00  -0.29172D-01   0.12545D-02   0.89376D-02
Aft Payload Gyro (left)           2168     0.88318D-02   0.00000D+00   0.00000D+00  -0.29172D-01   0.12545D-02   0.89376D-02
Aft Payload Gyro (left)           2168     0.88318D-02   0.00000D+00   0.00000D+00  -0.29172D-01   0.12545D-02   0.89376D-02

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.10409D+01  -0.33671D-01
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.10409D+01  -0.33671D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00   0.60120D-03   0.92269D-03   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.12600D+00  -0.53789D-02   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077     0.38457D-03  -0.11604D+01  -0.39839D-03  -0.31801D-01   0.61663D-03  -0.40313D-02

MODE # 5/ 13, Frequency (rad/sec), Damping (zeta), Generalized Mass=    16.599       0.10000E-01    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077    -0.17706D+01  -0.73207D-03   0.14421D+01  -0.14616D-02   0.88259D-01  -0.76727D-03
Shuttle Main Engine # 2           2243    -0.10343D+01  -0.20168D-02   0.16091D+01   0.92984D-04   0.88380D-01   0.32135D-02
Shuttle Main Engine # 3           2080    -0.10398D+01   0.43449D-02   0.16279D+01  -0.21828D-02   0.11191D+00  -0.30071D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.60923D+00   0.00000D+00   0.00000D+00  -0.21281D-02   0.88998D-01  -0.13868D-02
Aft Payload Gyro (left)           2168    -0.60923D+00   0.00000D+00   0.00000D+00  -0.21281D-02   0.88998D-01  -0.13868D-02
Aft Payload Gyro (left)           2168    -0.60923D+00   0.00000D+00   0.00000D+00  -0.21281D-02   0.88998D-01  -0.13868D-02

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.54201D-02  -0.72898D+00
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.54201D-02  -0.72898D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00  -0.26271D-03   0.25015D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.20955D-02  -0.34660D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077    -0.17706D+01  -0.73207D-03   0.14421D+01  -0.14616D-02   0.88259D-01  -0.76727D-03

MODE # 6/ 15, Frequency (rad/sec), Damping (zeta), Generalized Mass=    19.502       0.10000E-01    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077    -0.46980D-02   0.21567D+00   0.75820D-02   0.11424D-01   0.80970D-03   0.20951D-01
Shuttle Main Engine # 2           2243    -0.13879D-01   0.21920D+00  -0.67264D-01   0.15060D-01  -0.78491D-02  -0.25350D-02
Shuttle Main Engine # 3           2080     0.73222D-02   0.22228D+00   0.88515D-01   0.14938D-01   0.65729D-02  -0.49204D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.15545D-01   0.00000D+00   0.00000D+00   0.55271D-02  -0.25447D-02  -0.12654D-01
Aft Payload Gyro (left)           2168    -0.15545D-01   0.00000D+00   0.00000D+00   0.55271D-02  -0.25447D-02  -0.12654D-01
Aft Payload Gyro (left)           2168    -0.15545D-01   0.00000D+00   0.00000D+00   0.55271D-02  -0.25447D-02  -0.12654D-01

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.24739D+01  -0.76684D-01
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.24739D+01  -0.76684D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00   0.11216D+00   0.48113D-04   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.26288D+00   0.25918D-02   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077    -0.46980D-02   0.21567D+00   0.75820D-02   0.11424D-01   0.80970D-03   0.20951D-01

MODE # 7/ 16, Frequency (rad/sec), Damping (zeta), Generalized Mass=    21.689       0.10000E-01    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077     0.75480D+00  -0.37487D-01   0.25017D+00   0.12234D-02  -0.12451D-01  -0.12750D-03
Shuttle Main Engine # 2           2243     0.62583D+00  -0.46944D-01   0.20235D+00   0.29114D-02  -0.17801D-01  -0.10622D-02
Shuttle Main Engine # 3           2080     0.62086D+00  -0.52530D-01   0.21672D+00   0.19200D-02  -0.20046D-01   0.24577D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168     0.53369D+00   0.00000D+00   0.00000D+00  -0.45050D-04  -0.50810D-02   0.27028D-02
Aft Payload Gyro (left)           2168     0.53369D+00   0.00000D+00   0.00000D+00  -0.45050D-04  -0.50810D-02   0.27028D-02
Aft Payload Gyro (left)           2168     0.53369D+00   0.00000D+00   0.00000D+00  -0.45050D-04  -0.50810D-02   0.27028D-02

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.18458D-01   0.94369D+00
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.18458D-01   0.94369D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00  -0.23009D-02  -0.19497D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00   0.23936D-01   0.10914D+01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077     0.75480D+00  -0.37487D-01   0.25017D+00   0.12234D-02  -0.12451D-01  -0.12750D-03

MODE # 8/ 17, Frequency (rad/sec), Damping (zeta), Generalized Mass=    23.028       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077     0.37914D-02   0.20112D+01   0.62181D-02   0.29113D-01  -0.51889D-02   0.17652D-03
Shuttle Main Engine # 2           2243    -0.11655D+00   0.17710D+01  -0.19975D+00   0.45226D-01  -0.16298D-01  -0.21089D-01
Shuttle Main Engine # 3           2080     0.10455D+00   0.17796D+01   0.18496D+00   0.35364D-01   0.33767D-02  -0.31306D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.31813D-01   0.00000D+00   0.00000D+00   0.37902D-01  -0.43289D-02  -0.34223D-01
Aft Payload Gyro (left)           2168    -0.31813D-01   0.00000D+00   0.00000D+00   0.37902D-01  -0.43289D-02  -0.34223D-01
Aft Payload Gyro (left)           2168    -0.31813D-01   0.00000D+00   0.00000D+00   0.37902D-01  -0.43289D-02  -0.34223D-01

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.38640D+01  -0.12770D+00
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.38640D+01  -0.12770D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00   0.22596D+00  -0.12699D-02   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.93816D+00  -0.90951D-02   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077     0.37914D-02   0.20112D+01   0.62181D-02   0.29113D-01  -0.51889D-02   0.17652D-03

MODE # 9/ 20, Frequency (rad/sec), Damping (zeta), Generalized Mass=    29.714       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077     0.31270D-01  -0.23678D+00   0.23641D+00   0.83830D-01   0.21282D-01  -0.33862D-01
Shuttle Main Engine # 2           2243     0.32287D+00  -0.10464D+01  -0.13781D-01   0.70415D-01   0.43592D-01   0.27026D-01
Shuttle Main Engine # 3           2080     0.77004D-01  -0.10438D+01   0.58735D+00   0.61430D-01   0.47188D-01   0.22732D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168     0.26793D+00   0.00000D+00   0.00000D+00   0.33594D-01   0.21569D-02  -0.24738D-01
Aft Payload Gyro (left)           2168     0.26793D+00   0.00000D+00   0.00000D+00   0.33594D-01   0.21569D-02  -0.24738D-01
Aft Payload Gyro (left)           2168     0.26793D+00   0.00000D+00   0.00000D+00   0.33594D-01   0.21569D-02  -0.24738D-01

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.64365D+00   0.27813D-01
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.64365D+00   0.27813D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00  -0.26957D-01  -0.88181D-02   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00   0.76195D+00   0.21991D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077     0.31270D-01  -0.23678D+00   0.23641D+00   0.83830D-01   0.21282D-01  -0.33862D-01

MODE #10/ 21, Frequency (rad/sec), Damping (zeta), Generalized Mass=    30.196       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077    -0.15782D+00  -0.86794D-01  -0.10225D+01   0.24476D-01  -0.69882D-01  -0.39828D-02
Shuttle Main Engine # 2           2243    -0.54192D+00  -0.31287D+00  -0.11424D+01   0.13103D-01  -0.40408D-01   0.10836D-01
Shuttle Main Engine # 3           2080    -0.59770D+00  -0.30187D+00  -0.10777D+01   0.20674D-01  -0.12082D+00   0.48907D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.11361D+01   0.00000D+00   0.00000D+00   0.10710D-01  -0.76235D-01   0.41165D-02
Aft Payload Gyro (left)           2168    -0.11361D+01   0.00000D+00   0.00000D+00   0.10710D-01  -0.76235D-01   0.41165D-02
Aft Payload Gyro (left)           2168    -0.11361D+01   0.00000D+00   0.00000D+00   0.10710D-01  -0.76235D-01   0.41165D-02

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.16460D+00   0.46871D+00
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.16460D+00   0.46871D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00  -0.12421D-01   0.27507D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00   0.23220D+00  -0.58401D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077    -0.15782D+00  -0.86794D-01  -0.10225D+01   0.24476D-01  -0.69882D-01  -0.39828D-02

MODE #11/ 22, Frequency (rad/sec), Damping (zeta), Generalized Mass=    35.047       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077     0.72884D-01  -0.27897D-01   0.23937D+00  -0.39313D-02  -0.41623D-01  -0.35017D-02
Shuttle Main Engine # 2           2243    -0.25910D+00  -0.88788D-02   0.18625D+00  -0.42103D-02  -0.36970D-01   0.16362D-02
Shuttle Main Engine # 3           2080    -0.28079D+00  -0.89145D-02   0.16082D+00  -0.49393D-02  -0.21900D-01   0.23506D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.29042D+00   0.00000D+00   0.00000D+00  -0.13177D-01   0.93856D-02   0.28150D-01
Aft Payload Gyro (left)           2168    -0.29042D+00   0.00000D+00   0.00000D+00  -0.13177D-01   0.93856D-02   0.28150D-01
Aft Payload Gyro (left)           2168    -0.29042D+00   0.00000D+00   0.00000D+00  -0.13177D-01   0.93856D-02   0.28150D-01

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.45249D-02  -0.17132D+01
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.45249D-02  -0.17132D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00  -0.14557D-02   0.21755D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00   0.13421D-01  -0.15521D+01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077     0.72884D-01  -0.27897D-01   0.23937D+00  -0.39313D-02  -0.41623D-01  -0.35017D-02

MODE #12/ 24, Frequency (rad/sec), Damping (zeta), Generalized Mass=    36.204       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077     0.59830D+00  -0.47057D-01  -0.42961D+00   0.19626D-03   0.37200D-01   0.97680D-02
Shuttle Main Engine # 2           2243     0.92796D+00  -0.69439D-02  -0.34783D+00   0.40001D-03   0.35492D-01  -0.12467D-01
Shuttle Main Engine # 3           2080     0.95401D+00  -0.36175D-01  -0.43693D+00   0.92566D-02  -0.65166D-01   0.12542D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168     0.60376D+00   0.00000D+00   0.00000D+00   0.50016D-02   0.33940D-01   0.20816D-01
Aft Payload Gyro (left)           2168     0.60376D+00   0.00000D+00   0.00000D+00   0.50016D-02   0.33940D-01   0.20816D-01
Aft Payload Gyro (left)           2168     0.60376D+00   0.00000D+00   0.00000D+00   0.50016D-02   0.33940D-01   0.20816D-01

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.47211D-01  -0.52876D+00
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.47211D-01  -0.52876D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00  -0.80486D-02  -0.53624D-02   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00   0.44228D-01   0.50942D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077     0.59830D+00  -0.47057D-01  -0.42961D+00   0.19626D-03   0.37200D-01   0.97680D-02

MODE #13/ 25, Frequency (rad/sec), Damping (zeta), Generalized Mass=    37.357       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077     0.25305D-01  -0.68722D-02  -0.49114D+00  -0.69725D-03   0.14005D-01   0.24966D-02
Shuttle Main Engine # 2           2243     0.18722D+00   0.21098D-01  -0.41139D+00  -0.56621D-02   0.23886D-01  -0.83210D-02
Shuttle Main Engine # 3           2080     0.20817D+00   0.78025D-02  -0.49721D+00   0.34296D-02  -0.39715D-01   0.66426D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.95587D-02   0.00000D+00   0.00000D+00  -0.49934D-02   0.47939D-01   0.27668D-01
Aft Payload Gyro (left)           2168    -0.95587D-02   0.00000D+00   0.00000D+00  -0.49934D-02   0.47939D-01   0.27668D-01
Aft Payload Gyro (left)           2168    -0.95587D-02   0.00000D+00   0.00000D+00  -0.49934D-02   0.47939D-01   0.27668D-01

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.29168D-01  -0.65608D+00
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.29168D-01  -0.65608D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00   0.36148D-03  -0.20861D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.87925D-03   0.74638D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077     0.25305D-01  -0.68722D-02  -0.49114D+00  -0.69725D-03   0.14005D-01   0.24966D-02

MODE #14/ 26, Frequency (rad/sec), Damping (zeta), Generalized Mass=    38.970       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077    -0.21105D+00   0.26981D-01   0.41088D+00   0.36845D-02  -0.96004D-02   0.98975D-02
Shuttle Main Engine # 2           2243    -0.12119D+00  -0.32273D-01   0.40495D+00   0.95190D-02   0.29471D-02   0.10823D-01
Shuttle Main Engine # 3           2080    -0.11881D+00  -0.19361D-01   0.39036D+00   0.10930D-01  -0.73495D-01  -0.53219D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.43715D+00   0.00000D+00   0.00000D+00   0.21175D-01  -0.26262D-01  -0.15911D-01
Aft Payload Gyro (left)           2168    -0.43715D+00   0.00000D+00   0.00000D+00   0.21175D-01  -0.26262D-01  -0.15911D-01
Aft Payload Gyro (left)           2168    -0.43715D+00   0.00000D+00   0.00000D+00   0.21175D-01  -0.26262D-01  -0.15911D-01

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.56598D-02  -0.19274D+01
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.56598D-02  -0.19274D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00  -0.21863D-02   0.13783D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00   0.15993D-01  -0.23633D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077    -0.21105D+00   0.26981D-01   0.41088D+00   0.36845D-02  -0.96004D-02   0.98975D-02

MODE #15/ 27, Frequency (rad/sec), Damping (zeta), Generalized Mass=    44.884       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077    -0.36983D-01   0.50700D+00  -0.52090D-01   0.13990D+00  -0.15859D-01   0.48133D-01
Shuttle Main Engine # 2           2243     0.22310D+00  -0.83586D+00  -0.68879D+00   0.15317D+00  -0.21086D-02   0.61760D-01
Shuttle Main Engine # 3           2080    -0.23870D+00  -0.80410D+00   0.59533D+00   0.11573D+00   0.38239D-01   0.26185D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.44172D-01   0.00000D+00   0.00000D+00   0.10972D+00   0.64790D-02   0.13682D-01
Aft Payload Gyro (left)           2168    -0.44172D-01   0.00000D+00   0.00000D+00   0.10972D+00   0.64790D-02   0.13682D-01
Aft Payload Gyro (left)           2168    -0.44172D-01   0.00000D+00   0.00000D+00   0.10972D+00   0.64790D-02   0.13682D-01

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.19556D-01   0.94448D-01
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.19556D-01   0.94448D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00  -0.18823D+00  -0.16900D-02   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00   0.14390D+01  -0.18145D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077    -0.36983D-01   0.50700D+00  -0.52090D-01   0.13990D+00  -0.15859D-01   0.48133D-01

MODE #16/ 28, Frequency (rad/sec), Damping (zeta), Generalized Mass=    45.938       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077    -0.11870D+01  -0.20272D-01  -0.36855D+00  -0.26053D-02   0.31919D-01   0.15618D-02
Shuttle Main Engine # 2           2243    -0.71934D+00  -0.44501D-02  -0.13602D+00  -0.18026D-01   0.74683D-01   0.18552D-02
Shuttle Main Engine # 3           2080    -0.68625D+00   0.15804D-01  -0.28210D+00   0.28585D-02  -0.32291D-02  -0.48943D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.83883D+00   0.00000D+00   0.00000D+00  -0.52451D-02   0.50702D-01   0.18619D-01
Aft Payload Gyro (left)           2168    -0.83883D+00   0.00000D+00   0.00000D+00  -0.52451D-02   0.50702D-01   0.18619D-01
Aft Payload Gyro (left)           2168    -0.83883D+00   0.00000D+00   0.00000D+00  -0.52451D-02   0.50702D-01   0.18619D-01

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.14036D+00   0.27867D+01
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.14036D+00   0.27867D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00   0.76833D-02  -0.21411D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.42301D-01   0.85213D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077    -0.11870D+01  -0.20272D-01  -0.36855D+00  -0.26053D-02   0.31919D-01   0.15618D-02

MODE #17/ 30, Frequency (rad/sec), Damping (zeta), Generalized Mass=    49.589       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077     0.25604D+00  -0.55772D+00  -0.23970D+00   0.65497D-01  -0.50926D-02   0.16175D-01
Shuttle Main Engine # 2           2243     0.43447D+00  -0.12293D+01  -0.44936D+00   0.41126D-01   0.68164D-02   0.58048D-01
Shuttle Main Engine # 3           2080    -0.15052D+00  -0.12472D+01  -0.55562D-01   0.56549D-01  -0.15260D-01   0.79674D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168     0.12473D+00   0.00000D+00   0.00000D+00   0.22300D-01  -0.15706D-01   0.66481D-01
Aft Payload Gyro (left)           2168     0.12473D+00   0.00000D+00   0.00000D+00   0.22300D-01  -0.15706D-01   0.66481D-01
Aft Payload Gyro (left)           2168     0.12473D+00   0.00000D+00   0.00000D+00   0.22300D-01  -0.15706D-01   0.66481D-01

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.45026D+01  -0.24365D+00
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.45026D+01  -0.24365D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00   0.50270D-01  -0.57957D-02   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.19717D+00   0.16050D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077     0.25604D+00  -0.55772D+00  -0.23970D+00   0.65497D-01  -0.50926D-02   0.16175D-01

MODE #18/ 31, Frequency (rad/sec), Damping (zeta), Generalized Mass=    50.285       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077    -0.56006D+00  -0.21116D+00   0.94354D+00   0.16136D-01   0.46841D-01   0.63211D-02
Shuttle Main Engine # 2           2243    -0.20709D+00  -0.41288D+00   0.92949D+00   0.14226D-01   0.51228D-01   0.15278D-01
Shuttle Main Engine # 3           2080    -0.37299D+00  -0.42062D+00   0.11249D+01   0.24302D-01   0.88822D-01   0.23393D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168     0.20051D+00   0.00000D+00   0.00000D+00   0.15548D-01   0.64165D-01   0.30922D-01
Aft Payload Gyro (left)           2168     0.20051D+00   0.00000D+00   0.00000D+00   0.15548D-01   0.64165D-01   0.30922D-01
Aft Payload Gyro (left)           2168     0.20051D+00   0.00000D+00   0.00000D+00   0.15548D-01   0.64165D-01   0.30922D-01

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.12986D+01   0.54723D+00
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.12986D+01   0.54723D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00   0.85888D-02   0.48568D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.35440D-01  -0.62447D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077    -0.56006D+00  -0.21116D+00   0.94354D+00   0.16136D-01   0.46841D-01   0.63211D-02

MODE #19/ 34, Frequency (rad/sec), Damping (zeta), Generalized Mass=    52.381       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077     0.29438D+00  -0.94330D-01  -0.71952D+00   0.57126D-02  -0.30132D-01   0.43522D-03
Shuttle Main Engine # 2           2243     0.45833D-01  -0.86562D-01  -0.74841D+00  -0.51439D-02  -0.26662D-01  -0.49572D-02
Shuttle Main Engine # 3           2080     0.57702D-01  -0.88218D-01  -0.75139D+00   0.11877D-02  -0.29531D-01   0.21323D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.10610D+00   0.00000D+00   0.00000D+00  -0.79441D-02  -0.14549D-01   0.90616D-02
Aft Payload Gyro (left)           2168    -0.10610D+00   0.00000D+00   0.00000D+00  -0.79441D-02  -0.14549D-01   0.90616D-02
Aft Payload Gyro (left)           2168    -0.10610D+00   0.00000D+00   0.00000D+00  -0.79441D-02  -0.14549D-01   0.90616D-02

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.39641D-01   0.12090D+01
Orbiter IMU/Accelerom (right)     2311     0.00000D+00   0.39641D-01   0.12090D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00   0.67507D-02  -0.97767D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00  -0.32811D-01   0.15234D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077     0.29438D+00  -0.94330D-01  -0.71952D+00   0.57126D-02  -0.30132D-01   0.43522D-03

MODE #20/ 36, Frequency (rad/sec), Damping (zeta), Generalized Mass=    54.582       0.50000E-02    43216.    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  7 Engines, (x,y,z)...
Shuttle Main Engine # 1           2077     0.51608D-01  -0.10143D-02  -0.75586D+00   0.10606D-01  -0.20832D-01   0.34208D-02
Shuttle Main Engine # 2           2243     0.44531D-01  -0.51848D-01  -0.73710D+00   0.28644D-02  -0.31536D-02  -0.39218D-03
Shuttle Main Engine # 3           2080     0.70308D-01  -0.44862D-01  -0.75073D+00   0.53897D-02  -0.57048D-01  -0.25678D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Aft Payload Gyro (left)           2168    -0.31574D+00   0.00000D+00   0.00000D+00   0.99252D-02  -0.61601D-01  -0.94829D-02
Aft Payload Gyro (left)           2168    -0.31574D+00   0.00000D+00   0.00000D+00   0.99252D-02  -0.61601D-01  -0.94829D-02
Aft Payload Gyro (left)           2168    -0.31574D+00   0.00000D+00   0.00000D+00   0.99252D-02  -0.61601D-01  -0.94829D-02

                              Node ID#     Modal Data at the 10 Accelerometers, along (x,y,z)...
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.20465D+00  -0.41239D+00
Orbiter IMU/Accelerom (right)     2311     0.00000D+00  -0.20465D+00  -0.41239D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX SLOSH MASS                     227     0.00000D+00   0.12385D-02  -0.70674D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 SLOSH MASS                     228     0.00000D+00   0.41083D-02   0.35983D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
Shuttle Main Engine # 1           2077     0.51608D-01  -0.10143D-02  -0.75586D+00   0.10606D-01  -0.20832D-01   0.34208D-02

--------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Space Shuttle Second Stage at T=123 sec
System
vehicle.m
--------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Plant Model, Vehicle/Actuators/Sensors                                                                                    
System
plant.m
--------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Actuators/TVC (Second Stage)                                                                                    
System
actor_tvc.m
--------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Sensor Dynamics                                                                                    
System
sensors.m
--------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Shuttle Stage-2 Flight Control System                                                                                    
System
controller.m
--------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Space Shuttle Second Stage at T=123 sec (With Uncertain Param)                                      
System
Vehicle_unc.m
--------------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
