BATCH MODE INSTRUCTIONS ...............
Batch for Spacecraft with 4 SG CMG
! This batch set creates two flex spacecraft models controlled by four SGCMGs, 
! the second model includes also parameter uncertainties. The two models are
! converted to Matlab format for further analysis.
!
Flight Vehicle   : Flexible Agile Spacecraft Nominal                                                                                            
Flight Vehicle   : Flexible Agile Spacecraft Perturb                                                                                            
To Matlab Format : Flexible Agile Spacecraft Nominal                                                     
To Matlab Format : Flexible Agile Spacecraft Perturb                                                 
------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Flexible Agile Spacecraft Nominal
! This is a Flex Spacecraft model that includes four 1200 (ft-lb-sec) SGCMGs
Body Axes Output, Attitude=Euler Angles
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   202.05       32.17        0.20896E+08
Moments and products of Inertias Ixx, Iyy, Izz, -Ixy,-Ixz,-Iyz, in (lb-sec^2-ft)         :   1.410986E+4  1.30452E+4   0.175972E+4  0.3103E+2,   0.1187E+2,  0.16151e+3
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   0.0         -0.20975      0.62017   
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   0.0          25500.0      0.0          700000.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   0.0          0.0          0.0          0.0    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   0.0          0.0          0.0          0.0    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0000       0.000        0.0000       0.0000       0.0          0.0000    
External Force direction unit vect: (x,y,z), Force application point: (x,y,z)   (feet)   :   Force        1.0          0.0          0.0         -12.1463     -0.3083      -0.1383
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   1.0          1.0          1.0  
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :   0.0         -0.20975      0.62017      0.0
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   0.0          0.0          0.0          0.0          0.0          0.0000       0.0000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.0          0.0          0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:   0.0          0.0          0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.0          0.0          0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:   0.0          0.0          0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0          0.0          0.0000       0.0000       0.0000       0.0000    

Number of Single Gimbal Control Moment Gyros (SG CMG) ?                                  :  4
CMG: 1 Angular Momentum magnitude H0 (ft-lb-sec), Initial Gimbal Angle (delta) (deg)     :   1200.0       1.0
       Gimbal Direction Vector (m)                                                       :   0.92718385   0.0          0.37460659        
       Momentum Reference Direction Vector (r)                                           :   0.0          1.0          0.0
       SGCMG Surface Orientation angles in Pyramid (beta & gamma), (Figure 2.2)          :   68.0         90.0  
       SGCMG Moments of Inertia (Js, Jg, Jo) about: spin, gimbal and output axes         :   1.2          0.6          0.8  
CMG: 2 Angular Momentum magnitude H0 (ft-lb-sec), Initial Gimbal Angle (delta) (deg)     :   1200.0       0.0
       Gimbal Direction Vector (m)                                                       :   0.0          0.92718385   0.37460659
       Momentum Reference Direction Vector (r)                                           :  -1.0          0.0          0.0
       SGCMG Surface Orientation angles in Pyramid (beta & gamma), (Figure 2.2)          :   68.0         180.0  
       SGCMG Moments of Inertia (Js, Jg, Jo) about: spin, gimbal and output axes         :   1.2          0.6          0.8  
CMG: 3 Angular Momentum magnitude H0 (ft-lb-sec), Initial Gimbal Angle (delta) (deg)     :   1200.0       0.0
       Gimbal Direction Vector (m)                                                       :  -0.92718385   0.0          0.37460659        
       Momentum Reference Direction Vector (r)                                           :   0.0         -1.0          0.0
       SGCMG Surface Orientation angles in Pyramid (beta & gamma), (Figure 2.2)          :   68.0         270.0  
       SGCMG Moments of Inertia (Js, Jg, Jo) about: spin, gimbal and output axes         :   1.2          0.6          0.8  
CMG: 4 Angular Momentum magnitude H0 (ft-lb-sec), Initial Gimbal Angle (delta) (deg)     :   1200.0       0.0
       Gimbal Direction Vector (m)                                                       :   0.0         -0.92718385   0.37460659
       Momentum Reference Direction Vector (r)                                           :   1.0          0.0          0.0
       SGCMG Surface Orientation angles in Pyramid (beta & gamma), (Figure 2.2)          :   68.0         0.0  
       SGCMG Moments of Inertia (Js, Jg, Jo) about: spin, gimbal and output axes         :   1.2          0.6          0.8  

Number of Gyros, (Attitude and Rate)                                                     :  9
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 2    :  Roll   Attitude        6.5334	0.0       -1.1892
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 2    :  Pitch  Attitude        6.5334	0.0       -1.1892
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 2    :  Yaw    Attitude        6.5334	0.0       -1.1892
Gyro No  4 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 2    :  Roll   Rate            6.5334	0.0       -1.1892
Gyro No  5 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 2    :  Pitch  Rate            6.5334	0.0       -1.1892
Gyro No  6 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 2    :  Yaw    Rate            6.5334	0.0       -1.1892
Gyro No  7 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 1    :  Roll   Rate           -2.9379	0.2375    -0.2   
Gyro No  8 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 1    :  Pitch  Rate           -2.9379	0.2375    -0.2    
Gyro No  9 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 1    :  Yaw    Rate           -2.9379	0.2375    -0.2    

Number of Accelerometers, Along Axes: (x,y,z)                                            :  6
Acceleromet No  1 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Loc, Node 2   :  X-axis Accelerat.      6.5334	0.0       -1.1892
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Loc, Node 2   :  Y-axis Accelerat.      6.5334	0.0       -1.1892
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Loc, Node 2   :  Z-axis Accelerat.      6.5334	0.0       -1.1892
Acceleromet No  4 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Loc, Node 4   :  X-axis Accelerat.      5.2754	0.0       -2.09
Acceleromet No  5 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Loc, Node 4   :  Y-axis Accelerat.      5.2754	0.0       -2.09
Acceleromet No  6 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Loc, Node 4   :  Z-axis Accelerat.      5.2754	0.0       -2.09

Number of Bending Modes                                                                  : 40
Flexible Agile Spacecraft with 4 SG-CMG, All Flex Modes      
--------------------------------------------------------------------------------------------------------------------------------------------------------                                                                  
FLIGHT VEHICLE INPUT DATA ......
Flexible Agile Spacecraft Perturb
! This is a Flex Spacecraft model that includes four 1200 (ft-lb-sec) SGCMGs
Body Axes Output, Attitude=Euler Angles
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   202.05       32.17        0.20896E+08
Moments and products of Inertias Ixx, Iyy, Izz, -Ixy,-Ixz,-Iyz, in (lb-sec^2-ft)         :   1.410986E+4  1.30452E+4   0.175972E+4  0.3103E+2,   0.1187E+2,  0.16151e+3
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   0.0         -0.20975      0.62017   
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   0.0          25500.0      0.0          700000.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   0.0          0.0          0.0          0.0    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   0.0          0.0          0.0          0.0    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0000       0.000        0.0000       0.0000       0.0          0.0000    
External Force direction unit vect: (x,y,z), Force application point: (x,y,z)   (feet)   :   Force        1.0          0.0          0.0         -12.1463     -0.3083      -0.1383
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   1.0          1.0          1.0  
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :   0.0         -0.20975      0.62017      0.0
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   0.0          0.0          0.0          0.0          0.0          0.0000       0.0000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.0          0.0          0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:   0.0          0.0          0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.0          0.0          0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:   0.0          0.0          0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0          0.0          0.0000       0.0000       0.0000       0.0000    

Number of Single Gimbal Control Moment Gyros (SG CMG) ?                                  :  4
CMG: 1 Angular Momentum magnitude H0 (ft-lb-sec), Initial Gimbal Angle (delta) (deg)     :   1200.0       1.0
       Gimbal Direction Vector (m)                                                       :   0.42718385   0.2          0.57460659        
       Momentum Reference Direction Vector (r)                                           :   0.0          1.0          0.0
       SGCMG Surface Orientation angles in Pyramid (beta & gamma), (Figure 2.2)          :   68.0         90.0  
       SGCMG Moments of Inertia (Js, Jg, Jo) about: spin, gimbal and output axes         :   1.2          0.6          0.8  
CMG: 2 Angular Momentum magnitude H0 (ft-lb-sec), Initial Gimbal Angle (delta) (deg)     :   1200.0       0.0
       Gimbal Direction Vector (m)                                                       :   0.0          0.92718385   0.37460659
       Momentum Reference Direction Vector (r)                                           :  -1.0          0.0          0.0
       SGCMG Surface Orientation angles in Pyramid (beta & gamma), (Figure 2.2)          :   68.0         180.0  
       SGCMG Moments of Inertia (Js, Jg, Jo) about: spin, gimbal and output axes         :   1.2          0.6          0.8  
CMG: 3 Angular Momentum magnitude H0 (ft-lb-sec), Initial Gimbal Angle (delta) (deg)     :   1200.0       0.0
       Gimbal Direction Vector (m)                                                       :  -0.92718385   0.0          0.37460659        
       Momentum Reference Direction Vector (r)                                           :   0.0         -1.0          0.0
       SGCMG Surface Orientation angles in Pyramid (beta & gamma), (Figure 2.2)          :   68.0         270.0  
       SGCMG Moments of Inertia (Js, Jg, Jo) about: spin, gimbal and output axes         :   1.2          0.6          0.8  
CMG: 4 Angular Momentum magnitude H0 (ft-lb-sec), Initial Gimbal Angle (delta) (deg)     :   1200.0       0.0
       Gimbal Direction Vector (m)                                                       :   0.0         -0.92718385   0.37460659
       Momentum Reference Direction Vector (r)                                           :   1.0          0.0          0.0
       SGCMG Surface Orientation angles in Pyramid (beta & gamma), (Figure 2.2)          :   68.0         0.0  
       SGCMG Moments of Inertia (Js, Jg, Jo) about: spin, gimbal and output axes         :   1.2          0.6          0.8  

Number of Gyros, (Attitude and Rate)                                                     :  9
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 2    :  Roll   Attitude        6.5334	0.0       -1.1892
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 2    :  Pitch  Attitude        6.5334	0.0       -1.1892
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 2    :  Yaw    Attitude        6.5334	0.0       -1.1892
Gyro No  4 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 2    :  Roll   Rate            6.5334	0.0       -1.1892
Gyro No  5 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 2    :  Pitch  Rate            6.5334	0.0       -1.1892
Gyro No  6 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 2    :  Yaw    Rate            6.5334	0.0       -1.1892
Gyro No  7 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 1    :  Roll   Rate           -2.9379	0.2375    -0.2   
Gyro No  8 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 1    :  Pitch  Rate           -2.9379	0.2375    -0.2    
Gyro No  9 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Locat,   Node 1    :  Yaw    Rate           -2.9379	0.2375    -0.2    

Number of Accelerometers, Along Axes: (x,y,z)                                            :  6
Acceleromet No  1 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Loc, Node 2   :  X-axis Accelerat.      6.5334	0.0       -1.1892
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Loc, Node 2   :  Y-axis Accelerat.      6.5334	0.0       -1.1892
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Loc, Node 2   :  Z-axis Accelerat.      6.5334	0.0       -1.1892
Acceleromet No  4 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Loc, Node 4   :  X-axis Accelerat.      5.2754	0.0       -2.09
Acceleromet No  5 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Loc, Node 4   :  Y-axis Accelerat.      5.2754	0.0       -2.09
Acceleromet No  6 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Loc, Node 4   :  Z-axis Accelerat.      5.2754	0.0       -2.09

Number of Bending Modes                                                                  : 40
Flexible Agile Spacecraft with 4 SG-CMG, All Flex Modes      
--------------------------------------------------------------------------------------------------------------------------------------------------------                                                                  
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Flexible Agile Spacecraft Nominal
System
sc_4cmg_a
---------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Flexible Agile Spacecraft Perturb 
System
sc_4cmg_b
----------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR : All Flex M
Flexible Agile Spacecraft with 4 SG-CMG, All Flex Modes      
! All the flex modes are selected except for the first 6 rigid-body modes. A total of 40            
! structural modes.                                                                                 

MODE#  1/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    3.1905       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6     0.10717D-02  -0.16639D-01  -0.31137D-01  -0.42835D-01  -0.29132D-02  -0.32023D-03
Control Moment Gyros (CMG) Loc       6     0.10717D-02  -0.16639D-01  -0.31137D-01  -0.42835D-01  -0.29132D-02  -0.32023D-03
Control Moment Gyros (CMG) Loc       6     0.10717D-02  -0.16639D-01  -0.31137D-01  -0.42835D-01  -0.29132D-02  -0.32023D-03
Control Moment Gyros (CMG) Loc       6     0.10717D-02  -0.16639D-01  -0.31137D-01  -0.42835D-01  -0.29132D-02  -0.32023D-03

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2     0.45900D-02  -0.76587D-01   0.46744D-01  -0.42835D-01  -0.29132D-02  -0.32023D-03
Attitude, Rate, Accelerom Sens       2     0.45900D-02  -0.76587D-01   0.46744D-01  -0.42835D-01  -0.29132D-02  -0.32023D-03
Attitude, Rate, Accelerom Sens       2     0.45900D-02  -0.76587D-01   0.46744D-01  -0.42835D-01  -0.29132D-02  -0.32023D-03
Attitude, Rate, Accelerom Sens       2     0.45900D-02  -0.76587D-01   0.46744D-01  -0.42835D-01  -0.29132D-02  -0.32023D-03
Attitude, Rate, Accelerom Sens       2     0.45900D-02  -0.76587D-01   0.46744D-01  -0.42835D-01  -0.29132D-02  -0.32023D-03
Attitude, Rate, Accelerom Sens       2     0.45900D-02  -0.76587D-01   0.46744D-01  -0.42835D-01  -0.29132D-02  -0.32023D-03
Pointing Antena                      1     0.19735D-02  -0.34853D-01   0.29482D-01  -0.42912D-01  -0.26934D-02  -0.17005D-03
Pointing Antena                      1     0.19735D-02  -0.34853D-01   0.29482D-01  -0.42912D-01  -0.26934D-02  -0.17005D-03
Pointing Antena                      1     0.19735D-02  -0.34853D-01   0.29482D-01  -0.42912D-01  -0.26934D-02  -0.17005D-03

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2     0.45900D-02  -0.76587D-01   0.46744D-01
Attitude, Rate, Accelerom Sens       2     0.45900D-02  -0.76587D-01   0.46744D-01
Attitude, Rate, Accelerom Sens       2     0.45900D-02  -0.76587D-01   0.46744D-01
Solar Array Hinge                    4    -0.28312D-01   0.44163D-02   0.23976D+00
Solar Array Hinge                    4    -0.28312D-01   0.44163D-02   0.23976D+00
Solar Array Hinge                    4    -0.28312D-01   0.44163D-02   0.23976D+00

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5     0.16319D-02  -0.22063D-01  -0.79956D-01  -0.43084D-01  -0.27097D-02  -0.19524D-03

MODE#  2/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    4.1346       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6     0.80826D-03   0.11826D-02  -0.17823D-01   0.15293D-02  -0.14359D-02  -0.46188D-04
Control Moment Gyros (CMG) Loc       6     0.80826D-03   0.11826D-02  -0.17823D-01   0.15293D-02  -0.14359D-02  -0.46188D-04
Control Moment Gyros (CMG) Loc       6     0.80826D-03   0.11826D-02  -0.17823D-01   0.15293D-02  -0.14359D-02  -0.46188D-04
Control Moment Gyros (CMG) Loc       6     0.80826D-03   0.11826D-02  -0.17823D-01   0.15293D-02  -0.14359D-02  -0.46188D-04

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2     0.28048D-02   0.23912D-02   0.88590D-02   0.15293D-02  -0.14359D-02  -0.46188D-04
Attitude, Rate, Accelerom Sens       2     0.28048D-02   0.23912D-02   0.88590D-02   0.15293D-02  -0.14359D-02  -0.46188D-04
Attitude, Rate, Accelerom Sens       2     0.28048D-02   0.23912D-02   0.88590D-02   0.15293D-02  -0.14359D-02  -0.46188D-04
Attitude, Rate, Accelerom Sens       2     0.28048D-02   0.23912D-02   0.88590D-02   0.15293D-02  -0.14359D-02  -0.46188D-04
Attitude, Rate, Accelerom Sens       2     0.28048D-02   0.23912D-02   0.88590D-02   0.15293D-02  -0.14359D-02  -0.46188D-04
Attitude, Rate, Accelerom Sens       2     0.28048D-02   0.23912D-02   0.88590D-02   0.15293D-02  -0.14359D-02  -0.46188D-04
Pointing Antena                      1     0.13280D-02   0.89083D-03   0.54152D-02   0.14258D-02  -0.14976D-02  -0.50743D-04
Pointing Antena                      1     0.13280D-02   0.89083D-03   0.54152D-02   0.14258D-02  -0.14976D-02  -0.50743D-04
Pointing Antena                      1     0.13280D-02   0.89083D-03   0.54152D-02   0.14258D-02  -0.14976D-02  -0.50743D-04

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2     0.28048D-02   0.23912D-02   0.88590D-02
Attitude, Rate, Accelerom Sens       2     0.28048D-02   0.23912D-02   0.88590D-02
Attitude, Rate, Accelerom Sens       2     0.28048D-02   0.23912D-02   0.88590D-02
Solar Array Hinge                    4     0.13464D-02  -0.16660D-01  -0.18497D-01
Solar Array Hinge                    4     0.13464D-02  -0.16660D-01  -0.18497D-01
Solar Array Hinge                    4     0.13464D-02  -0.16660D-01  -0.18497D-01

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5     0.10564D-02   0.13730D-02  -0.16497D-01   0.14366D-02  -0.15018D-02  -0.48314D-04

MODE#  3/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    5.8336       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6     0.26123D-01  -0.61404D-01  -0.54589D-02   0.27061D-03   0.59705D-03   0.52944D-02
Control Moment Gyros (CMG) Loc       6     0.26123D-01  -0.61404D-01  -0.54589D-02   0.27061D-03   0.59705D-03   0.52944D-02
Control Moment Gyros (CMG) Loc       6     0.26123D-01  -0.61404D-01  -0.54589D-02   0.27061D-03   0.59705D-03   0.52944D-02
Control Moment Gyros (CMG) Loc       6     0.26123D-01  -0.61404D-01  -0.54589D-02   0.27061D-03   0.59705D-03   0.52944D-02

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2     0.30554D-01   0.30773D-01   0.34400D-02   0.27061D-03   0.59705D-03   0.52944D-02
Attitude, Rate, Accelerom Sens       2     0.30554D-01   0.30773D-01   0.34400D-02   0.27061D-03   0.59705D-03   0.52944D-02
Attitude, Rate, Accelerom Sens       2     0.30554D-01   0.30773D-01   0.34400D-02   0.27061D-03   0.59705D-03   0.52944D-02
Attitude, Rate, Accelerom Sens       2     0.30554D-01   0.30773D-01   0.34400D-02   0.27061D-03   0.59705D-03   0.52944D-02
Attitude, Rate, Accelerom Sens       2     0.30554D-01   0.30773D-01   0.34400D-02   0.27061D-03   0.59705D-03   0.52944D-02
Attitude, Rate, Accelerom Sens       2     0.30554D-01   0.30773D-01   0.34400D-02   0.27061D-03   0.59705D-03   0.52944D-02
Pointing Antena                      1     0.28449D-01   0.20764D-01   0.31779D-02   0.27674D-03  -0.55003D-03   0.51563D-02
Pointing Antena                      1     0.28449D-01   0.20764D-01   0.31779D-02   0.27674D-03  -0.55003D-03   0.51563D-02
Pointing Antena                      1     0.28449D-01   0.20764D-01   0.31779D-02   0.27674D-03  -0.55003D-03   0.51563D-02

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2     0.30554D-01   0.30773D-01   0.34400D-02
Attitude, Rate, Accelerom Sens       2     0.30554D-01   0.30773D-01   0.34400D-02
Attitude, Rate, Accelerom Sens       2     0.30554D-01   0.30773D-01   0.34400D-02
Solar Array Hinge                    4     0.30217D-01  -0.45931D+00  -0.57814D-02
Solar Array Hinge                    4     0.30217D-01  -0.45931D+00  -0.57814D-02
Solar Array Hinge                    4     0.30217D-01  -0.45931D+00  -0.57814D-02

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5     0.20396D-01  -0.62317D-01  -0.52477D-02   0.16189D-03  -0.81527D-03   0.51629D-02

MODE#  4/ 10, Frequency (rad/sec), Damping (zeta), Generalized Mass=    6.2473       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6    -0.15887D-03  -0.17366D-02   0.36435D-01   0.20335D-01  -0.62927D-04  -0.29938D-03
Control Moment Gyros (CMG) Loc       6    -0.15887D-03  -0.17366D-02   0.36435D-01   0.20335D-01  -0.62927D-04  -0.29938D-03
Control Moment Gyros (CMG) Loc       6    -0.15887D-03  -0.17366D-02   0.36435D-01   0.20335D-01  -0.62927D-04  -0.29938D-03
Control Moment Gyros (CMG) Loc       6    -0.15887D-03  -0.17366D-02   0.36435D-01   0.20335D-01  -0.62927D-04  -0.29938D-03

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2     0.62798D-03   0.21142D-01   0.29261D-01   0.20335D-01  -0.62927D-04  -0.29938D-03
Attitude, Rate, Accelerom Sens       2     0.62798D-03   0.21142D-01   0.29261D-01   0.20335D-01  -0.62927D-04  -0.29938D-03
Attitude, Rate, Accelerom Sens       2     0.62798D-03   0.21142D-01   0.29261D-01   0.20335D-01  -0.62927D-04  -0.29938D-03
Attitude, Rate, Accelerom Sens       2     0.62798D-03   0.21142D-01   0.29261D-01   0.20335D-01  -0.62927D-04  -0.29938D-03
Attitude, Rate, Accelerom Sens       2     0.62798D-03   0.21142D-01   0.29261D-01   0.20335D-01  -0.62927D-04  -0.29938D-03
Attitude, Rate, Accelerom Sens       2     0.62798D-03   0.21142D-01   0.29261D-01   0.20335D-01  -0.62927D-04  -0.29938D-03
Pointing Antena                      1    -0.17011D-03   0.12179D-02   0.32402D-01   0.20555D-01  -0.28282D-03  -0.28098D-03
Pointing Antena                      1    -0.17011D-03   0.12179D-02   0.32402D-01   0.20555D-01  -0.28282D-03  -0.28098D-03
Pointing Antena                      1    -0.17011D-03   0.12179D-02   0.32402D-01   0.20555D-01  -0.28282D-03  -0.28098D-03

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2     0.62798D-03   0.21142D-01   0.29261D-01
Attitude, Rate, Accelerom Sens       2     0.62798D-03   0.21142D-01   0.29261D-01
Attitude, Rate, Accelerom Sens       2     0.62798D-03   0.21142D-01   0.29261D-01
Solar Array Hinge                    4     0.58905D-02   0.61343D-02   0.37942D-01
Solar Array Hinge                    4     0.58905D-02   0.61343D-02   0.37942D-01
Solar Array Hinge                    4     0.58905D-02   0.61343D-02   0.37942D-01

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5     0.18378D-03   0.96048D-03   0.59504D-01   0.20783D-01  -0.36488D-03  -0.27800D-03

MODE#  5/ 11, Frequency (rad/sec), Damping (zeta), Generalized Mass=    8.7916       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6    -0.13837D-03   0.16261D-02   0.38632D-02   0.54948D-02   0.34565D-03   0.38042D-04
Control Moment Gyros (CMG) Loc       6    -0.13837D-03   0.16261D-02   0.38632D-02   0.54948D-02   0.34565D-03   0.38042D-04
Control Moment Gyros (CMG) Loc       6    -0.13837D-03   0.16261D-02   0.38632D-02   0.54948D-02   0.34565D-03   0.38042D-04
Control Moment Gyros (CMG) Loc       6    -0.13837D-03   0.16261D-02   0.38632D-02   0.54948D-02   0.34565D-03   0.38042D-04

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2    -0.30791D-03   0.47942D-02  -0.33734D-02   0.54948D-02   0.34565D-03   0.38042D-04
Attitude, Rate, Accelerom Sens       2    -0.30791D-03   0.47942D-02  -0.33734D-02   0.54948D-02   0.34565D-03   0.38042D-04
Attitude, Rate, Accelerom Sens       2    -0.30791D-03   0.47942D-02  -0.33734D-02   0.54948D-02   0.34565D-03   0.38042D-04
Attitude, Rate, Accelerom Sens       2    -0.30791D-03   0.47942D-02  -0.33734D-02   0.54948D-02   0.34565D-03   0.38042D-04
Attitude, Rate, Accelerom Sens       2    -0.30791D-03   0.47942D-02  -0.33734D-02   0.54948D-02   0.34565D-03   0.38042D-04
Attitude, Rate, Accelerom Sens       2    -0.30791D-03   0.47942D-02  -0.33734D-02   0.54948D-02   0.34565D-03   0.38042D-04
Pointing Antena                      1    -0.24172D-03   0.22206D-02  -0.14371D-02   0.55288D-02   0.18852D-03  -0.87995D-04
Pointing Antena                      1    -0.24172D-03   0.22206D-02  -0.14371D-02   0.55288D-02   0.18852D-03  -0.87995D-04
Pointing Antena                      1    -0.24172D-03   0.22206D-02  -0.14371D-02   0.55288D-02   0.18852D-03  -0.87995D-04

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2    -0.30791D-03   0.47942D-02  -0.33734D-02
Attitude, Rate, Accelerom Sens       2    -0.30791D-03   0.47942D-02  -0.33734D-02
Attitude, Rate, Accelerom Sens       2    -0.30791D-03   0.47942D-02  -0.33734D-02
Solar Array Hinge                    4    -0.14834D-01   0.19730D-02  -0.44682D+00
Solar Array Hinge                    4    -0.14834D-01   0.19730D-02  -0.44682D+00
Solar Array Hinge                    4    -0.14834D-01   0.19730D-02  -0.44682D+00

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5    -0.84952D-04   0.23314D-02   0.10141D-01   0.56827D-02   0.19703D-03  -0.72604D-04

MODE#  6/ 12, Frequency (rad/sec), Damping (zeta), Generalized Mass=    10.588       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6    -0.20406D-03   0.67535D-02   0.75502D-02  -0.17776D-01  -0.19459D-03   0.13430D-03
Control Moment Gyros (CMG) Loc       6    -0.20406D-03   0.67535D-02   0.75502D-02  -0.17776D-01  -0.19459D-03   0.13430D-03
Control Moment Gyros (CMG) Loc       6    -0.20406D-03   0.67535D-02   0.75502D-02  -0.17776D-01  -0.19459D-03   0.13430D-03
Control Moment Gyros (CMG) Loc       6    -0.20406D-03   0.67535D-02   0.75502D-02  -0.17776D-01  -0.19459D-03   0.13430D-03

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2     0.13464D-02  -0.14311D-01   0.26383D-01  -0.17776D-01  -0.19459D-03   0.13430D-03
Attitude, Rate, Accelerom Sens       2     0.13464D-02  -0.14311D-01   0.26383D-01  -0.17776D-01  -0.19459D-03   0.13430D-03
Attitude, Rate, Accelerom Sens       2     0.13464D-02  -0.14311D-01   0.26383D-01  -0.17776D-01  -0.19459D-03   0.13430D-03
Attitude, Rate, Accelerom Sens       2     0.13464D-02  -0.14311D-01   0.26383D-01  -0.17776D-01  -0.19459D-03   0.13430D-03
Attitude, Rate, Accelerom Sens       2     0.13464D-02  -0.14311D-01   0.26383D-01  -0.17776D-01  -0.19459D-03   0.13430D-03
Attitude, Rate, Accelerom Sens       2     0.13464D-02  -0.14311D-01   0.26383D-01  -0.17776D-01  -0.19459D-03   0.13430D-03
Pointing Antena                      1    -0.29878D-04   0.32132D-02   0.19221D-01  -0.18218D-01  -0.25609D-03   0.19110D-03
Pointing Antena                      1    -0.29878D-04   0.32132D-02   0.19221D-01  -0.18218D-01  -0.25609D-03   0.19110D-03
Pointing Antena                      1    -0.29878D-04   0.32132D-02   0.19221D-01  -0.18218D-01  -0.25609D-03   0.19110D-03

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2     0.13464D-02  -0.14311D-01   0.26383D-01
Attitude, Rate, Accelerom Sens       2     0.13464D-02  -0.14311D-01   0.26383D-01
Attitude, Rate, Accelerom Sens       2     0.13464D-02  -0.14311D-01   0.26383D-01
Solar Array Hinge                    4     0.94338D-02  -0.10498D-02  -0.36213D-01
Solar Array Hinge                    4     0.94338D-02  -0.10498D-02  -0.36213D-01
Solar Array Hinge                    4     0.94338D-02  -0.10498D-02  -0.36213D-01

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5    -0.30984D-03   0.43829D-02  -0.13269D-01  -0.18744D-01  -0.41651D-03   0.20045D-03

MODE#  7/ 13, Frequency (rad/sec), Damping (zeta), Generalized Mass=    10.937       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6    -0.29191D-03   0.80653D-02   0.74106D-03   0.55840D-02   0.16406D-03   0.22867D-04
Control Moment Gyros (CMG) Loc       6    -0.29191D-03   0.80653D-02   0.74106D-03   0.55840D-02   0.16406D-03   0.22867D-04
Control Moment Gyros (CMG) Loc       6    -0.29191D-03   0.80653D-02   0.74106D-03   0.55840D-02   0.16406D-03   0.22867D-04
Control Moment Gyros (CMG) Loc       6    -0.29191D-03   0.80653D-02   0.74106D-03   0.55840D-02   0.16406D-03   0.22867D-04

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2    -0.38285D-03   0.15081D-01  -0.55645D-02   0.55840D-02   0.16406D-03   0.22867D-04
Attitude, Rate, Accelerom Sens       2    -0.38285D-03   0.15081D-01  -0.55645D-02   0.55840D-02   0.16406D-03   0.22867D-04
Attitude, Rate, Accelerom Sens       2    -0.38285D-03   0.15081D-01  -0.55645D-02   0.55840D-02   0.16406D-03   0.22867D-04
Attitude, Rate, Accelerom Sens       2    -0.38285D-03   0.15081D-01  -0.55645D-02   0.55840D-02   0.16406D-03   0.22867D-04
Attitude, Rate, Accelerom Sens       2    -0.38285D-03   0.15081D-01  -0.55645D-02   0.55840D-02   0.16406D-03   0.22867D-04
Attitude, Rate, Accelerom Sens       2    -0.38285D-03   0.15081D-01  -0.55645D-02   0.55840D-02   0.16406D-03   0.22867D-04
Pointing Antena                      1    -0.35867D-03   0.96627D-02  -0.41680D-02   0.56582D-02   0.16138D-03  -0.27293D-04
Pointing Antena                      1    -0.35867D-03   0.96627D-02  -0.41680D-02   0.56582D-02   0.16138D-03  -0.27293D-04
Pointing Antena                      1    -0.35867D-03   0.96627D-02  -0.41680D-02   0.56582D-02   0.16138D-03  -0.27293D-04

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2    -0.38285D-03   0.15081D-01  -0.55645D-02
Attitude, Rate, Accelerom Sens       2    -0.38285D-03   0.15081D-01  -0.55645D-02
Attitude, Rate, Accelerom Sens       2    -0.38285D-03   0.15081D-01  -0.55645D-02
Solar Array Hinge                    4     0.68619D-02   0.34972D-03   0.70163D-02
Solar Array Hinge                    4     0.68619D-02   0.34972D-03   0.70163D-02
Solar Array Hinge                    4     0.68619D-02   0.34972D-03   0.70163D-02

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5    -0.26902D-03   0.87627D-02   0.71353D-02   0.60491D-02   0.20464D-03   0.73772D-04

MODE#  8/ 14, Frequency (rad/sec), Damping (zeta), Generalized Mass=    11.003       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6     0.22588D-03   0.14863D-01  -0.81697D-03   0.23444D-02   0.12184D-04   0.72511D-04
Control Moment Gyros (CMG) Loc       6     0.22588D-03   0.14863D-01  -0.81697D-03   0.23444D-02   0.12184D-04   0.72511D-04
Control Moment Gyros (CMG) Loc       6     0.22588D-03   0.14863D-01  -0.81697D-03   0.23444D-02   0.12184D-04   0.72511D-04
Control Moment Gyros (CMG) Loc       6     0.22588D-03   0.14863D-01  -0.81697D-03   0.23444D-02   0.12184D-04   0.72511D-04

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2    -0.11335D-04   0.18337D-01  -0.21702D-02   0.23444D-02   0.12184D-04   0.72511D-04
Attitude, Rate, Accelerom Sens       2    -0.11335D-04   0.18337D-01  -0.21702D-02   0.23444D-02   0.12184D-04   0.72511D-04
Attitude, Rate, Accelerom Sens       2    -0.11335D-04   0.18337D-01  -0.21702D-02   0.23444D-02   0.12184D-04   0.72511D-04
Attitude, Rate, Accelerom Sens       2    -0.11335D-04   0.18337D-01  -0.21702D-02   0.23444D-02   0.12184D-04   0.72511D-04
Attitude, Rate, Accelerom Sens       2    -0.11335D-04   0.18337D-01  -0.21702D-02   0.23444D-02   0.12184D-04   0.72511D-04
Attitude, Rate, Accelerom Sens       2    -0.11335D-04   0.18337D-01  -0.21702D-02   0.23444D-02   0.12184D-04   0.72511D-04
Pointing Antena                      1     0.24692D-03   0.15690D-01  -0.10630D-02   0.23116D-02  -0.43688D-04   0.52981D-06
Pointing Antena                      1     0.24692D-03   0.15690D-01  -0.10630D-02   0.23116D-02  -0.43688D-04   0.52981D-06
Pointing Antena                      1     0.24692D-03   0.15690D-01  -0.10630D-02   0.23116D-02  -0.43688D-04   0.52981D-06

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2    -0.11335D-04   0.18337D-01  -0.21702D-02
Attitude, Rate, Accelerom Sens       2    -0.11335D-04   0.18337D-01  -0.21702D-02
Attitude, Rate, Accelerom Sens       2    -0.11335D-04   0.18337D-01  -0.21702D-02
Solar Array Hinge                    4     0.16016D-01   0.25309D-03   0.74725D-02
Solar Array Hinge                    4     0.16016D-01   0.25309D-03   0.74725D-02
Solar Array Hinge                    4     0.16016D-01   0.25309D-03   0.74725D-02

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5     0.23960D-03   0.15059D-01   0.17224D-02   0.27294D-02  -0.44898D-04   0.16189D-03

MODE#  9/ 15, Frequency (rad/sec), Damping (zeta), Generalized Mass=    17.376       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6     0.22525D-02  -0.24155D-02  -0.34931D-03   0.78614D-03   0.47482D-03   0.32680D-03
Control Moment Gyros (CMG) Loc       6     0.22525D-02  -0.24155D-02  -0.34931D-03   0.78614D-03   0.47482D-03   0.32680D-03
Control Moment Gyros (CMG) Loc       6     0.22525D-02  -0.24155D-02  -0.34931D-03   0.78614D-03   0.47482D-03   0.32680D-03
Control Moment Gyros (CMG) Loc       6     0.22525D-02  -0.24155D-02  -0.34931D-03   0.78614D-03   0.47482D-03   0.32680D-03

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2     0.24284D-02   0.11215D-02  -0.17339D-02   0.78614D-03   0.47482D-03   0.32680D-03
Attitude, Rate, Accelerom Sens       2     0.24284D-02   0.11215D-02  -0.17339D-02   0.78614D-03   0.47482D-03   0.32680D-03
Attitude, Rate, Accelerom Sens       2     0.24284D-02   0.11215D-02  -0.17339D-02   0.78614D-03   0.47482D-03   0.32680D-03
Attitude, Rate, Accelerom Sens       2     0.24284D-02   0.11215D-02  -0.17339D-02   0.78614D-03   0.47482D-03   0.32680D-03
Attitude, Rate, Accelerom Sens       2     0.24284D-02   0.11215D-02  -0.17339D-02   0.78614D-03   0.47482D-03   0.32680D-03
Attitude, Rate, Accelerom Sens       2     0.24284D-02   0.11215D-02  -0.17339D-02   0.78614D-03   0.47482D-03   0.32680D-03
Pointing Antena                      1     0.23537D-02   0.19704D-02  -0.79476D-03   0.84966D-03   0.57149D-05   0.25560D-03
Pointing Antena                      1     0.23537D-02   0.19704D-02  -0.79476D-03   0.84966D-03   0.57149D-05   0.25560D-03
Pointing Antena                      1     0.23537D-02   0.19704D-02  -0.79476D-03   0.84966D-03   0.57149D-05   0.25560D-03

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2     0.24284D-02   0.11215D-02  -0.17339D-02
Attitude, Rate, Accelerom Sens       2     0.24284D-02   0.11215D-02  -0.17339D-02
Attitude, Rate, Accelerom Sens       2     0.24284D-02   0.11215D-02  -0.17339D-02
Solar Array Hinge                    4    -0.40962D-02  -0.15024D+00  -0.12458D+00
Solar Array Hinge                    4    -0.40962D-02  -0.15024D+00  -0.12458D+00
Solar Array Hinge                    4    -0.40962D-02  -0.15024D+00  -0.12458D+00

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5     0.19580D-02  -0.23452D-02   0.62494D-03   0.92284D-03  -0.19862D-03   0.28453D-03

MODE# 10/ 16, Frequency (rad/sec), Damping (zeta), Generalized Mass=    18.104       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6     0.12363D-02  -0.29524D-02  -0.89996D-02  -0.93746D-02  -0.30614D-02  -0.13608D-02
Control Moment Gyros (CMG) Loc       6     0.12363D-02  -0.29524D-02  -0.89996D-02  -0.93746D-02  -0.30614D-02  -0.13608D-02
Control Moment Gyros (CMG) Loc       6     0.12363D-02  -0.29524D-02  -0.89996D-02  -0.93746D-02  -0.30614D-02  -0.13608D-02
Control Moment Gyros (CMG) Loc       6     0.12363D-02  -0.29524D-02  -0.89996D-02  -0.93746D-02  -0.30614D-02  -0.13608D-02

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2     0.31777D-02  -0.49939D-02   0.29201D-01  -0.93746D-02  -0.30614D-02  -0.13608D-02
Attitude, Rate, Accelerom Sens       2     0.31777D-02  -0.49939D-02   0.29201D-01  -0.93746D-02  -0.30614D-02  -0.13608D-02
Attitude, Rate, Accelerom Sens       2     0.31777D-02  -0.49939D-02   0.29201D-01  -0.93746D-02  -0.30614D-02  -0.13608D-02
Attitude, Rate, Accelerom Sens       2     0.31777D-02  -0.49939D-02   0.29201D-01  -0.93746D-02  -0.30614D-02  -0.13608D-02
Attitude, Rate, Accelerom Sens       2     0.31777D-02  -0.49939D-02   0.29201D-01  -0.93746D-02  -0.30614D-02  -0.13608D-02
Attitude, Rate, Accelerom Sens       2     0.31777D-02  -0.49939D-02   0.29201D-01  -0.93746D-02  -0.30614D-02  -0.13608D-02
Pointing Antena                      1     0.15523D-02  -0.16199D-01   0.20844D-01  -0.11757D-01  -0.15622D-02  -0.56692D-03
Pointing Antena                      1     0.15523D-02  -0.16199D-01   0.20844D-01  -0.11757D-01  -0.15622D-02  -0.56692D-03
Pointing Antena                      1     0.15523D-02  -0.16199D-01   0.20844D-01  -0.11757D-01  -0.15622D-02  -0.56692D-03

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2     0.31777D-02  -0.49939D-02   0.29201D-01
Attitude, Rate, Accelerom Sens       2     0.31777D-02  -0.49939D-02   0.29201D-01
Attitude, Rate, Accelerom Sens       2     0.31777D-02  -0.49939D-02   0.29201D-01
Solar Array Hinge                    4     0.92673D-01  -0.12039D-01   0.17645D+01
Solar Array Hinge                    4     0.92673D-01  -0.12039D-01   0.17645D+01
Solar Array Hinge                    4     0.92673D-01  -0.12039D-01   0.17645D+01

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5     0.22638D-02  -0.41474D-02  -0.22671D-01  -0.13657D-01  -0.20788D-02  -0.10061D-02

MODE# 11/ 17, Frequency (rad/sec), Damping (zeta), Generalized Mass=    22.475       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6     0.28841D-02  -0.22825D-02   0.16128D-02  -0.51248D-03   0.23575D-03   0.15812D-03
Control Moment Gyros (CMG) Loc       6     0.28841D-02  -0.22825D-02   0.16128D-02  -0.51248D-03   0.23575D-03   0.15812D-03
Control Moment Gyros (CMG) Loc       6     0.28841D-02  -0.22825D-02   0.16128D-02  -0.51248D-03   0.23575D-03   0.15812D-03
Control Moment Gyros (CMG) Loc       6     0.28841D-02  -0.22825D-02   0.16128D-02  -0.51248D-03   0.23575D-03   0.15812D-03

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2     0.31472D-02   0.10180D-02   0.13213D-03  -0.51248D-03   0.23575D-03   0.15812D-03
Attitude, Rate, Accelerom Sens       2     0.31472D-02   0.10180D-02   0.13213D-03  -0.51248D-03   0.23575D-03   0.15812D-03
Attitude, Rate, Accelerom Sens       2     0.31472D-02   0.10180D-02   0.13213D-03  -0.51248D-03   0.23575D-03   0.15812D-03
Attitude, Rate, Accelerom Sens       2     0.31472D-02   0.10180D-02   0.13213D-03  -0.51248D-03   0.23575D-03   0.15812D-03
Attitude, Rate, Accelerom Sens       2     0.31472D-02   0.10180D-02   0.13213D-03  -0.51248D-03   0.23575D-03   0.15812D-03
Attitude, Rate, Accelerom Sens       2     0.31472D-02   0.10180D-02   0.13213D-03  -0.51248D-03   0.23575D-03   0.15812D-03
Pointing Antena                      1     0.29175D-02   0.89365D-03  -0.40672D-03  -0.36848D-03   0.13646D-03   0.20675D-03
Pointing Antena                      1     0.29175D-02   0.89365D-03  -0.40672D-03  -0.36848D-03   0.13646D-03   0.20675D-03
Pointing Antena                      1     0.29175D-02   0.89365D-03  -0.40672D-03  -0.36848D-03   0.13646D-03   0.20675D-03

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2     0.31472D-02   0.10180D-02   0.13213D-03
Attitude, Rate, Accelerom Sens       2     0.31472D-02   0.10180D-02   0.13213D-03
Attitude, Rate, Accelerom Sens       2     0.31472D-02   0.10180D-02   0.13213D-03
Solar Array Hinge                    4     0.35165D-02  -0.60089D-01   0.72904D-01
Solar Array Hinge                    4     0.35165D-02  -0.60089D-01   0.72904D-01
Solar Array Hinge                    4     0.35165D-02  -0.60089D-01   0.72904D-01

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5     0.26541D-02  -0.23210D-02   0.11725D-02  -0.50803D-03  -0.39971D-03   0.20234D-03

MODE# 12/ 18, Frequency (rad/sec), Damping (zeta), Generalized Mass=    25.199       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6     0.12090D-02  -0.18222D-02  -0.32384D-02  -0.25213D-02  -0.23392D-02  -0.21388D-02
Control Moment Gyros (CMG) Loc       6     0.12090D-02  -0.18222D-02  -0.32384D-02  -0.25213D-02  -0.23392D-02  -0.21388D-02
Control Moment Gyros (CMG) Loc       6     0.12090D-02  -0.18222D-02  -0.32384D-02  -0.25213D-02  -0.23392D-02  -0.21388D-02
Control Moment Gyros (CMG) Loc       6     0.12090D-02  -0.18222D-02  -0.32384D-02  -0.25213D-02  -0.23392D-02  -0.21388D-02

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2     0.45029D-03  -0.80720D-02   0.89928D-02  -0.25213D-02  -0.23392D-02  -0.21388D-02
Attitude, Rate, Accelerom Sens       2     0.45029D-03  -0.80720D-02   0.89928D-02  -0.25213D-02  -0.23392D-02  -0.21388D-02
Attitude, Rate, Accelerom Sens       2     0.45029D-03  -0.80720D-02   0.89928D-02  -0.25213D-02  -0.23392D-02  -0.21388D-02
Attitude, Rate, Accelerom Sens       2     0.45029D-03  -0.80720D-02   0.89928D-02  -0.25213D-02  -0.23392D-02  -0.21388D-02
Attitude, Rate, Accelerom Sens       2     0.45029D-03  -0.80720D-02   0.89928D-02  -0.25213D-02  -0.23392D-02  -0.21388D-02
Attitude, Rate, Accelerom Sens       2     0.45029D-03  -0.80720D-02   0.89928D-02  -0.25213D-02  -0.23392D-02  -0.21388D-02
Pointing Antena                      1     0.76978D-03  -0.25483D-01   0.53059D-02  -0.55064D-02  -0.38785D-03  -0.13618D-02
Pointing Antena                      1     0.76978D-03  -0.25483D-01   0.53059D-02  -0.55064D-02  -0.38785D-03  -0.13618D-02
Pointing Antena                      1     0.76978D-03  -0.25483D-01   0.53059D-02  -0.55064D-02  -0.38785D-03  -0.13618D-02

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2     0.45029D-03  -0.80720D-02   0.89928D-02
Attitude, Rate, Accelerom Sens       2     0.45029D-03  -0.80720D-02   0.89928D-02
Attitude, Rate, Accelerom Sens       2     0.45029D-03  -0.80720D-02   0.89928D-02
Solar Array Hinge                    4     0.49072D-01  -0.25881D-01   0.53630D+00
Solar Array Hinge                    4     0.49072D-01  -0.25881D-01   0.53630D+00
Solar Array Hinge                    4     0.49072D-01  -0.25881D-01   0.53630D+00

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5     0.30096D-02  -0.20216D-02  -0.96483D-02  -0.89131D-02  -0.65642D-03  -0.27248D-02

MODE# 13/ 19, Frequency (rad/sec), Damping (zeta), Generalized Mass=    25.625       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6     0.81986D-02   0.13794D-01  -0.12385D-01  -0.12761D-02  -0.43969D-03  -0.11062D-02
Control Moment Gyros (CMG) Loc       6     0.81986D-02   0.13794D-01  -0.12385D-01  -0.12761D-02  -0.43969D-03  -0.11062D-02
Control Moment Gyros (CMG) Loc       6     0.81986D-02   0.13794D-01  -0.12385D-01  -0.12761D-02  -0.43969D-03  -0.11062D-02
Control Moment Gyros (CMG) Loc       6     0.81986D-02   0.13794D-01  -0.12385D-01  -0.12761D-02  -0.43969D-03  -0.11062D-02

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2     0.92847D-02  -0.11986D-01   0.58002D-02  -0.12761D-02  -0.43969D-03  -0.11062D-02
Attitude, Rate, Accelerom Sens       2     0.92847D-02  -0.11986D-01   0.58002D-02  -0.12761D-02  -0.43969D-03  -0.11062D-02
Attitude, Rate, Accelerom Sens       2     0.92847D-02  -0.11986D-01   0.58002D-02  -0.12761D-02  -0.43969D-03  -0.11062D-02
Attitude, Rate, Accelerom Sens       2     0.92847D-02  -0.11986D-01   0.58002D-02  -0.12761D-02  -0.43969D-03  -0.11062D-02
Attitude, Rate, Accelerom Sens       2     0.92847D-02  -0.11986D-01   0.58002D-02  -0.12761D-02  -0.43969D-03  -0.11062D-02
Attitude, Rate, Accelerom Sens       2     0.92847D-02  -0.11986D-01   0.58002D-02  -0.12761D-02  -0.43969D-03  -0.11062D-02
Pointing Antena                      1     0.81379D-02  -0.67075D-02   0.86367D-02   0.24290D-04  -0.13130D-02  -0.12818D-02
Pointing Antena                      1     0.81379D-02  -0.67075D-02   0.86367D-02   0.24290D-04  -0.13130D-02  -0.12818D-02
Pointing Antena                      1     0.81379D-02  -0.67075D-02   0.86367D-02   0.24290D-04  -0.13130D-02  -0.12818D-02

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2     0.92847D-02  -0.11986D-01   0.58002D-02
Attitude, Rate, Accelerom Sens       2     0.92847D-02  -0.11986D-01   0.58002D-02
Attitude, Rate, Accelerom Sens       2     0.92847D-02  -0.11986D-01   0.58002D-02
Solar Array Hinge                    4    -0.48561D-02   0.62684D-02   0.35084D-01
Solar Array Hinge                    4    -0.48561D-02   0.62684D-02   0.35084D-01
Solar Array Hinge                    4    -0.48561D-02   0.62684D-02   0.35084D-01

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5     0.97067D-02   0.13454D-01  -0.12448D-01   0.68822D-03  -0.34958D-02  -0.12667D-02

MODE# 14/ 20, Frequency (rad/sec), Damping (zeta), Generalized Mass=    28.346       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6    -0.52432D-02   0.11890D-01   0.10341D-01  -0.82007D-03  -0.62404D-03  -0.78982D-03
Control Moment Gyros (CMG) Loc       6    -0.52432D-02   0.11890D-01   0.10341D-01  -0.82007D-03  -0.62404D-03  -0.78982D-03
Control Moment Gyros (CMG) Loc       6    -0.52432D-02   0.11890D-01   0.10341D-01  -0.82007D-03  -0.62404D-03  -0.78982D-03
Control Moment Gyros (CMG) Loc       6    -0.52432D-02   0.11890D-01   0.10341D-01  -0.82007D-03  -0.62404D-03  -0.78982D-03

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2    -0.75148D-02  -0.12611D-01  -0.38929D-02  -0.82007D-03  -0.62404D-03  -0.78982D-03
Attitude, Rate, Accelerom Sens       2    -0.75148D-02  -0.12611D-01  -0.38929D-02  -0.82007D-03  -0.62404D-03  -0.78982D-03
Attitude, Rate, Accelerom Sens       2    -0.75148D-02  -0.12611D-01  -0.38929D-02  -0.82007D-03  -0.62404D-03  -0.78982D-03
Attitude, Rate, Accelerom Sens       2    -0.75148D-02  -0.12611D-01  -0.38929D-02  -0.82007D-03  -0.62404D-03  -0.78982D-03
Attitude, Rate, Accelerom Sens       2    -0.75148D-02  -0.12611D-01  -0.38929D-02  -0.82007D-03  -0.62404D-03  -0.78982D-03
Attitude, Rate, Accelerom Sens       2    -0.75148D-02  -0.12611D-01  -0.38929D-02  -0.82007D-03  -0.62404D-03  -0.78982D-03
Pointing Antena                      1    -0.60063D-02  -0.38219D-02  -0.75475D-02   0.43061D-03   0.11101D-02  -0.98798D-03
Pointing Antena                      1    -0.60063D-02  -0.38219D-02  -0.75475D-02   0.43061D-03   0.11101D-02  -0.98798D-03
Pointing Antena                      1    -0.60063D-02  -0.38219D-02  -0.75475D-02   0.43061D-03   0.11101D-02  -0.98798D-03

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2    -0.75148D-02  -0.12611D-01  -0.38929D-02
Attitude, Rate, Accelerom Sens       2    -0.75148D-02  -0.12611D-01  -0.38929D-02
Attitude, Rate, Accelerom Sens       2    -0.75148D-02  -0.12611D-01  -0.38929D-02
Solar Array Hinge                    4    -0.11648D-01  -0.33517D-01   0.14943D-01
Solar Array Hinge                    4    -0.11648D-01  -0.33517D-01   0.14943D-01
Solar Array Hinge                    4    -0.11648D-01  -0.33517D-01   0.14943D-01

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5    -0.42422D-02   0.11745D-01   0.10429D-01   0.13840D-02   0.34554D-02  -0.84466D-03

MODE# 15/ 21, Frequency (rad/sec), Damping (zeta), Generalized Mass=    32.543       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6    -0.24083D-01   0.13925D-01   0.88825D-02  -0.21378D-02  -0.42571D-02   0.47827D-04
Control Moment Gyros (CMG) Loc       6    -0.24083D-01   0.13925D-01   0.88825D-02  -0.21378D-02  -0.42571D-02   0.47827D-04
Control Moment Gyros (CMG) Loc       6    -0.24083D-01   0.13925D-01   0.88825D-02  -0.21378D-02  -0.42571D-02   0.47827D-04
Control Moment Gyros (CMG) Loc       6    -0.24083D-01   0.13925D-01   0.88825D-02  -0.21378D-02  -0.42571D-02   0.47827D-04

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2    -0.24468D-01  -0.13956D-01  -0.80468D-03  -0.21378D-02  -0.42571D-02   0.47827D-04
Attitude, Rate, Accelerom Sens       2    -0.24468D-01  -0.13956D-01  -0.80468D-03  -0.21378D-02  -0.42571D-02   0.47827D-04
Attitude, Rate, Accelerom Sens       2    -0.24468D-01  -0.13956D-01  -0.80468D-03  -0.21378D-02  -0.42571D-02   0.47827D-04
Attitude, Rate, Accelerom Sens       2    -0.24468D-01  -0.13956D-01  -0.80468D-03  -0.21378D-02  -0.42571D-02   0.47827D-04
Attitude, Rate, Accelerom Sens       2    -0.24468D-01  -0.13956D-01  -0.80468D-03  -0.21378D-02  -0.42571D-02   0.47827D-04
Attitude, Rate, Accelerom Sens       2    -0.24468D-01  -0.13956D-01  -0.80468D-03  -0.21378D-02  -0.42571D-02   0.47827D-04
Pointing Antena                      1    -0.24695D-01   0.30610D-02  -0.10272D-01   0.10935D-02   0.11612D-02  -0.69152D-03
Pointing Antena                      1    -0.24695D-01   0.30610D-02  -0.10272D-01   0.10935D-02   0.11612D-02  -0.69152D-03
Pointing Antena                      1    -0.24695D-01   0.30610D-02  -0.10272D-01   0.10935D-02   0.11612D-02  -0.69152D-03

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2    -0.24468D-01  -0.13956D-01  -0.80468D-03
Attitude, Rate, Accelerom Sens       2    -0.24468D-01  -0.13956D-01  -0.80468D-03
Attitude, Rate, Accelerom Sens       2    -0.24468D-01  -0.13956D-01  -0.80468D-03
Solar Array Hinge                    4    -0.21384D-01   0.16607D+01   0.44799D-01
Solar Array Hinge                    4    -0.21384D-01   0.16607D+01   0.44799D-01
Solar Array Hinge                    4    -0.21384D-01   0.16607D+01   0.44799D-01

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5    -0.23712D-01   0.13584D-01   0.10188D-01   0.43049D-02   0.12377D+07   0.36768D-03

MODE# 16/ 22, Frequency (rad/sec), Damping (zeta), Generalized Mass=    35.847       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6    -0.38642D-02   0.10230D-02   0.72619D-02   0.27439D-02   0.54631D-03  -0.21035D-02
Control Moment Gyros (CMG) Loc       6    -0.38642D-02   0.10230D-02   0.72619D-02   0.27439D-02   0.54631D-03  -0.21035D-02
Control Moment Gyros (CMG) Loc       6    -0.38642D-02   0.10230D-02   0.72619D-02   0.27439D-02   0.54631D-03  -0.21035D-02
Control Moment Gyros (CMG) Loc       6    -0.38642D-02   0.10230D-02   0.72619D-02   0.27439D-02   0.54631D-03  -0.21035D-02

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2    -0.52350D-02   0.24246D-01  -0.29582D-02   0.27439D-02   0.54631D-03  -0.21035D-02
Attitude, Rate, Accelerom Sens       2    -0.52350D-02   0.24246D-01  -0.29582D-02   0.27439D-02   0.54631D-03  -0.21035D-02
Attitude, Rate, Accelerom Sens       2    -0.52350D-02   0.24246D-01  -0.29582D-02   0.27439D-02   0.54631D-03  -0.21035D-02
Attitude, Rate, Accelerom Sens       2    -0.52350D-02   0.24246D-01  -0.29582D-02   0.27439D-02   0.54631D-03  -0.21035D-02
Attitude, Rate, Accelerom Sens       2    -0.52350D-02   0.24246D-01  -0.29582D-02   0.27439D-02   0.54631D-03  -0.21035D-02
Attitude, Rate, Accelerom Sens       2    -0.52350D-02   0.24246D-01  -0.29582D-02   0.27439D-02   0.54631D-03  -0.21035D-02
Pointing Antena                      1    -0.47205D-02  -0.18970D-01  -0.86342D-02  -0.25493D-02   0.10607D-02  -0.11931D-02
Pointing Antena                      1    -0.47205D-02  -0.18970D-01  -0.86342D-02  -0.25493D-02   0.10607D-02  -0.11931D-02
Pointing Antena                      1    -0.47205D-02  -0.18970D-01  -0.86342D-02  -0.25493D-02   0.10607D-02  -0.11931D-02

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2    -0.52350D-02   0.24246D-01  -0.29582D-02
Attitude, Rate, Accelerom Sens       2    -0.52350D-02   0.24246D-01  -0.29582D-02
Attitude, Rate, Accelerom Sens       2    -0.52350D-02   0.24246D-01  -0.29582D-02
Solar Array Hinge                    4     0.11552D-01   0.15587D-01   0.49543D-01
Solar Array Hinge                    4     0.11552D-01   0.15587D-01   0.49543D-01
Solar Array Hinge                    4     0.11552D-01   0.15587D-01   0.49543D-01

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5    -0.23090D-02   0.13196D-02   0.41132D-02  -0.91668D-02   0.62645D-02  -0.45655D-02

MODE# 17/ 23, Frequency (rad/sec), Damping (zeta), Generalized Mass=    37.817       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6    -0.49451D-02  -0.69983D-02   0.10856D-01  -0.23777D-02   0.32261D-02   0.65848D-02
Control Moment Gyros (CMG) Loc       6    -0.49451D-02  -0.69983D-02   0.10856D-01  -0.23777D-02   0.32261D-02   0.65848D-02
Control Moment Gyros (CMG) Loc       6    -0.49451D-02  -0.69983D-02   0.10856D-01  -0.23777D-02   0.32261D-02   0.65848D-02
Control Moment Gyros (CMG) Loc       6    -0.49451D-02  -0.69983D-02   0.10856D-01  -0.23777D-02   0.32261D-02   0.65848D-02

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2    -0.33676D-02  -0.52991D-01  -0.11696D-01  -0.23777D-02   0.32261D-02   0.65848D-02
Attitude, Rate, Accelerom Sens       2    -0.33676D-02  -0.52991D-01  -0.11696D-01  -0.23777D-02   0.32261D-02   0.65848D-02
Attitude, Rate, Accelerom Sens       2    -0.33676D-02  -0.52991D-01  -0.11696D-01  -0.23777D-02   0.32261D-02   0.65848D-02
Attitude, Rate, Accelerom Sens       2    -0.33676D-02  -0.52991D-01  -0.11696D-01  -0.23777D-02   0.32261D-02   0.65848D-02
Attitude, Rate, Accelerom Sens       2    -0.33676D-02  -0.52991D-01  -0.11696D-01  -0.23777D-02   0.32261D-02   0.65848D-02
Attitude, Rate, Accelerom Sens       2    -0.33676D-02  -0.52991D-01  -0.11696D-01  -0.23777D-02   0.32261D-02   0.65848D-02
Pointing Antena                      1    -0.36217D-02   0.58622D-01  -0.87883D-02   0.97997D-02   0.95299D-03   0.38820D-02
Pointing Antena                      1    -0.36217D-02   0.58622D-01  -0.87883D-02   0.97997D-02   0.95299D-03   0.38820D-02
Pointing Antena                      1    -0.36217D-02   0.58622D-01  -0.87883D-02   0.97997D-02   0.95299D-03   0.38820D-02

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2    -0.33676D-02  -0.52991D-01  -0.11696D-01
Attitude, Rate, Accelerom Sens       2    -0.33676D-02  -0.52991D-01  -0.11696D-01
Attitude, Rate, Accelerom Sens       2    -0.33676D-02  -0.52991D-01  -0.11696D-01
Solar Array Hinge                    4    -0.15626D+00   0.36180D-01  -0.17786D+01
Solar Array Hinge                    4    -0.15626D+00   0.36180D-01  -0.17786D+01
Solar Array Hinge                    4    -0.15626D+00   0.36180D-01  -0.17786D+01

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5    -0.10184D-01  -0.68882D-02   0.22147D-01   0.35723D-01   0.45377D-02   0.17399D-01

MODE# 18/ 24, Frequency (rad/sec), Damping (zeta), Generalized Mass=    38.529       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6     0.55031D-02  -0.21227D-02  -0.11287D-01   0.29464D-02   0.22363D-02  -0.46343D-03
Control Moment Gyros (CMG) Loc       6     0.55031D-02  -0.21227D-02  -0.11287D-01   0.29464D-02   0.22363D-02  -0.46343D-03
Control Moment Gyros (CMG) Loc       6     0.55031D-02  -0.21227D-02  -0.11287D-01   0.29464D-02   0.22363D-02  -0.46343D-03
Control Moment Gyros (CMG) Loc       6     0.55031D-02  -0.21227D-02  -0.11287D-01   0.29464D-02   0.22363D-02  -0.46343D-03

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2     0.56051D-02   0.18692D-01  -0.12339D-02   0.29464D-02   0.22363D-02  -0.46343D-03
Attitude, Rate, Accelerom Sens       2     0.56051D-02   0.18692D-01  -0.12339D-02   0.29464D-02   0.22363D-02  -0.46343D-03
Attitude, Rate, Accelerom Sens       2     0.56051D-02   0.18692D-01  -0.12339D-02   0.29464D-02   0.22363D-02  -0.46343D-03
Attitude, Rate, Accelerom Sens       2     0.56051D-02   0.18692D-01  -0.12339D-02   0.29464D-02   0.22363D-02  -0.46343D-03
Attitude, Rate, Accelerom Sens       2     0.56051D-02   0.18692D-01  -0.12339D-02   0.29464D-02   0.22363D-02  -0.46343D-03
Attitude, Rate, Accelerom Sens       2     0.56051D-02   0.18692D-01  -0.12339D-02   0.29464D-02   0.22363D-02  -0.46343D-03
Pointing Antena                      1     0.58176D-02  -0.51231D-02   0.89560D-02   0.24310D-03  -0.12668D-02  -0.19626D-03
Pointing Antena                      1     0.58176D-02  -0.51231D-02   0.89560D-02   0.24310D-03  -0.12668D-02  -0.19626D-03
Pointing Antena                      1     0.58176D-02  -0.51231D-02   0.89560D-02   0.24310D-03  -0.12668D-02  -0.19626D-03

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2     0.56051D-02   0.18692D-01  -0.12339D-02
Attitude, Rate, Accelerom Sens       2     0.56051D-02   0.18692D-01  -0.12339D-02
Attitude, Rate, Accelerom Sens       2     0.56051D-02   0.18692D-01  -0.12339D-02
Solar Array Hinge                    4    -0.41363D-01   0.80072D-02  -0.75773D+00
Solar Array Hinge                    4    -0.41363D-01   0.80072D-02  -0.75773D+00
Solar Array Hinge                    4    -0.41363D-01   0.80072D-02  -0.75773D+00

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5     0.59116D-02  -0.18040D-02  -0.10364D-01  -0.19135D-02  -0.91228D-02  -0.16050D-02

MODE# 19/ 25, Frequency (rad/sec), Damping (zeta), Generalized Mass=    45.845       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6     0.19041D-01   0.94651D-01  -0.31594D-01   0.32362D-01   0.11543D-01  -0.38785D-01
Control Moment Gyros (CMG) Loc       6     0.19041D-01   0.94651D-01  -0.31594D-01   0.32362D-01   0.11543D-01  -0.38785D-01
Control Moment Gyros (CMG) Loc       6     0.19041D-01   0.94651D-01  -0.31594D-01   0.32362D-01   0.11543D-01  -0.38785D-01
Control Moment Gyros (CMG) Loc       6     0.19041D-01   0.94651D-01  -0.31594D-01   0.32362D-01   0.11543D-01  -0.38785D-01

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2    -0.46294D-03   0.43179D+00  -0.13851D-02   0.32362D-01   0.11543D-01  -0.38785D-01
Attitude, Rate, Accelerom Sens       2    -0.46294D-03   0.43179D+00  -0.13851D-02   0.32362D-01   0.11543D-01  -0.38785D-01
Attitude, Rate, Accelerom Sens       2    -0.46294D-03   0.43179D+00  -0.13851D-02   0.32362D-01   0.11543D-01  -0.38785D-01
Attitude, Rate, Accelerom Sens       2    -0.46294D-03   0.43179D+00  -0.13851D-02   0.32362D-01   0.11543D-01  -0.38785D-01
Attitude, Rate, Accelerom Sens       2    -0.46294D-03   0.43179D+00  -0.13851D-02   0.32362D-01   0.11543D-01  -0.38785D-01
Attitude, Rate, Accelerom Sens       2    -0.46294D-03   0.43179D+00  -0.13851D-02   0.32362D-01   0.11543D-01  -0.38785D-01
Pointing Antena                      1     0.71597D-02  -0.39143D+00   0.46394D-02  -0.36499D-01  -0.13078D-02  -0.29351D-01
Pointing Antena                      1     0.71597D-02  -0.39143D+00   0.46394D-02  -0.36499D-01  -0.13078D-02  -0.29351D-01
Pointing Antena                      1     0.71597D-02  -0.39143D+00   0.46394D-02  -0.36499D-01  -0.13078D-02  -0.29351D-01

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2    -0.46294D-03   0.43179D+00  -0.13851D-02
Attitude, Rate, Accelerom Sens       2    -0.46294D-03   0.43179D+00  -0.13851D-02
Attitude, Rate, Accelerom Sens       2    -0.46294D-03   0.43179D+00  -0.13851D-02
Solar Array Hinge                    4     0.10723D+00   0.23148D-01  -0.26866D+00
Solar Array Hinge                    4     0.10723D+00   0.23148D-01  -0.26866D+00
Solar Array Hinge                    4     0.10723D+00   0.23148D-01  -0.26866D+00

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5     0.53372D-01   0.91344D-01  -0.68587D-01  -0.63598D+00   0.87952D-01  -0.43524D+00

MODE# 20/ 26, Frequency (rad/sec), Damping (zeta), Generalized Mass=    47.919       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6     0.78051D-02  -0.50143D-02   0.32662D-01  -0.28021D-02  -0.80639D-02   0.34285D-02
Control Moment Gyros (CMG) Loc       6     0.78051D-02  -0.50143D-02   0.32662D-01  -0.28021D-02  -0.80639D-02   0.34285D-02
Control Moment Gyros (CMG) Loc       6     0.78051D-02  -0.50143D-02   0.32662D-01  -0.28021D-02  -0.80639D-02   0.34285D-02
Control Moment Gyros (CMG) Loc       6     0.78051D-02  -0.50143D-02   0.32662D-01  -0.28021D-02  -0.80639D-02   0.34285D-02

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2     0.42395D-01  -0.35536D-01   0.45312D-02  -0.28021D-02  -0.80639D-02   0.34285D-02
Attitude, Rate, Accelerom Sens       2     0.42395D-01  -0.35536D-01   0.45312D-02  -0.28021D-02  -0.80639D-02   0.34285D-02
Attitude, Rate, Accelerom Sens       2     0.42395D-01  -0.35536D-01   0.45312D-02  -0.28021D-02  -0.80639D-02   0.34285D-02
Attitude, Rate, Accelerom Sens       2     0.42395D-01  -0.35536D-01   0.45312D-02  -0.28021D-02  -0.80639D-02   0.34285D-02
Attitude, Rate, Accelerom Sens       2     0.42395D-01  -0.35536D-01   0.45312D-02  -0.28021D-02  -0.80639D-02   0.34285D-02
Attitude, Rate, Accelerom Sens       2     0.42395D-01  -0.35536D-01   0.45312D-02  -0.28021D-02  -0.80639D-02   0.34285D-02
Pointing Antena                      1     0.50960D-02   0.34749D-01  -0.73372D-01   0.28373D-02   0.68039D-02   0.23358D-02
Pointing Antena                      1     0.50960D-02   0.34749D-01  -0.73372D-01   0.28373D-02   0.68039D-02   0.23358D-02
Pointing Antena                      1     0.50960D-02   0.34749D-01  -0.73372D-01   0.28373D-02   0.68039D-02   0.23358D-02

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2     0.42395D-01  -0.35536D-01   0.45312D-02
Attitude, Rate, Accelerom Sens       2     0.42395D-01  -0.35536D-01   0.45312D-02
Attitude, Rate, Accelerom Sens       2     0.42395D-01  -0.35536D-01   0.45312D-02
Solar Array Hinge                    4    -0.64863D-02  -0.12110D-01   0.17512D-01
Solar Array Hinge                    4    -0.64863D-02  -0.12110D-01   0.17512D-01
Solar Array Hinge                    4    -0.64863D-02  -0.12110D-01   0.17512D-01

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5     0.12653D-01  -0.44249D-02   0.35892D-01  -0.71844D-01   0.17881D+01  -0.13380D-01

MODE# 21/ 27, Frequency (rad/sec), Damping (zeta), Generalized Mass=    50.289       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6    -0.43689D-02   0.41194D-02   0.99726D-02  -0.16862D-01  -0.62618D-02   0.21240D-01
Control Moment Gyros (CMG) Loc       6    -0.43689D-02   0.41194D-02   0.99726D-02  -0.16862D-01  -0.62618D-02   0.21240D-01
Control Moment Gyros (CMG) Loc       6    -0.43689D-02   0.41194D-02   0.99726D-02  -0.16862D-01  -0.62618D-02   0.21240D-01
Control Moment Gyros (CMG) Loc       6    -0.43689D-02   0.41194D-02   0.99726D-02  -0.16862D-01  -0.62618D-02   0.21240D-01

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2    -0.20932D-02  -0.22861D+00  -0.40617D-03  -0.16862D-01  -0.62618D-02   0.21240D-01
Attitude, Rate, Accelerom Sens       2    -0.20932D-02  -0.22861D+00  -0.40617D-03  -0.16862D-01  -0.62618D-02   0.21240D-01
Attitude, Rate, Accelerom Sens       2    -0.20932D-02  -0.22861D+00  -0.40617D-03  -0.16862D-01  -0.62618D-02   0.21240D-01
Attitude, Rate, Accelerom Sens       2    -0.20932D-02  -0.22861D+00  -0.40617D-03  -0.16862D-01  -0.62618D-02   0.21240D-01
Attitude, Rate, Accelerom Sens       2    -0.20932D-02  -0.22861D+00  -0.40617D-03  -0.16862D-01  -0.62618D-02   0.21240D-01
Attitude, Rate, Accelerom Sens       2    -0.20932D-02  -0.22861D+00  -0.40617D-03  -0.16862D-01  -0.62618D-02   0.21240D-01
Pointing Antena                      1    -0.12172D-02   0.10590D+00   0.17423D-01   0.10880D-01  -0.11435D-02   0.62879D-02
Pointing Antena                      1    -0.12172D-02   0.10590D+00   0.17423D-01   0.10880D-01  -0.11435D-02   0.62879D-02
Pointing Antena                      1    -0.12172D-02   0.10590D+00   0.17423D-01   0.10880D-01  -0.11435D-02   0.62879D-02

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2    -0.20932D-02  -0.22861D+00  -0.40617D-03
Attitude, Rate, Accelerom Sens       2    -0.20932D-02  -0.22861D+00  -0.40617D-03
Attitude, Rate, Accelerom Sens       2    -0.20932D-02  -0.22861D+00  -0.40617D-03
Solar Array Hinge                    4    -0.45173D-01  -0.40361D-02   0.92558D-01
Solar Array Hinge                    4    -0.45173D-01  -0.40361D-02   0.92558D-01
Solar Array Hinge                    4    -0.45173D-01  -0.40361D-02   0.92558D-01

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5    -0.27347D-01  -0.35003D-02   0.37642D-01  -0.10572D+01  -0.14323D+00  -0.86992D+00

MODE# 22/ 28, Frequency (rad/sec), Damping (zeta), Generalized Mass=    54.514       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6     0.95386D-02   0.15073D-02  -0.20587D-01  -0.29800D-03   0.22092D-01  -0.72760D-03
Control Moment Gyros (CMG) Loc       6     0.95386D-02   0.15073D-02  -0.20587D-01  -0.29800D-03   0.22092D-01  -0.72760D-03
Control Moment Gyros (CMG) Loc       6     0.95386D-02   0.15073D-02  -0.20587D-01  -0.29800D-03   0.22092D-01  -0.72760D-03
Control Moment Gyros (CMG) Loc       6     0.95386D-02   0.15073D-02  -0.20587D-01  -0.29800D-03   0.22092D-01  -0.72760D-03

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2    -0.36550D-01   0.40700D-03   0.32710D-02  -0.29800D-03   0.22092D-01  -0.72760D-03
Attitude, Rate, Accelerom Sens       2    -0.36550D-01   0.40700D-03   0.32710D-02  -0.29800D-03   0.22092D-01  -0.72760D-03
Attitude, Rate, Accelerom Sens       2    -0.36550D-01   0.40700D-03   0.32710D-02  -0.29800D-03   0.22092D-01  -0.72760D-03
Attitude, Rate, Accelerom Sens       2    -0.36550D-01   0.40700D-03   0.32710D-02  -0.29800D-03   0.22092D-01  -0.72760D-03
Attitude, Rate, Accelerom Sens       2    -0.36550D-01   0.40700D-03   0.32710D-02  -0.29800D-03   0.22092D-01  -0.72760D-03
Attitude, Rate, Accelerom Sens       2    -0.36550D-01   0.40700D-03   0.32710D-02  -0.29800D-03   0.22092D-01  -0.72760D-03
Pointing Antena                      1     0.12631D-01  -0.13247D-01   0.15387D+00  -0.10753D-02  -0.10786D-01  -0.89712D-03
Pointing Antena                      1     0.12631D-01  -0.13247D-01   0.15387D+00  -0.10753D-02  -0.10786D-01  -0.89712D-03
Pointing Antena                      1     0.12631D-01  -0.13247D-01   0.15387D+00  -0.10753D-02  -0.10786D-01  -0.89712D-03

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2    -0.36550D-01   0.40700D-03   0.32710D-02
Attitude, Rate, Accelerom Sens       2    -0.36550D-01   0.40700D-03   0.32710D-02
Attitude, Rate, Accelerom Sens       2    -0.36550D-01   0.40700D-03   0.32710D-02
Solar Array Hinge                    4    -0.56497D-02  -0.32853D-02   0.74626D-02
Solar Array Hinge                    4    -0.56497D-02  -0.32853D-02   0.74626D-02
Solar Array Hinge                    4    -0.56497D-02  -0.32853D-02   0.74626D-02

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5     0.11955D-01   0.14774D-02  -0.16860D-01   0.27234D-01   0.12398D+00   0.26125D-01

MODE# 23/ 29, Frequency (rad/sec), Damping (zeta), Generalized Mass=    55.649       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6     0.37484D-02   0.12610D+00   0.14020D-02   0.14560D-01  -0.26936D-02  -0.17748D-01
Control Moment Gyros (CMG) Loc       6     0.37484D-02   0.12610D+00   0.14020D-02   0.14560D-01  -0.26936D-02  -0.17748D-01
Control Moment Gyros (CMG) Loc       6     0.37484D-02   0.12610D+00   0.14020D-02   0.14560D-01  -0.26936D-02  -0.17748D-01
Control Moment Gyros (CMG) Loc       6     0.37484D-02   0.12610D+00   0.14020D-02   0.14560D-01  -0.26936D-02  -0.17748D-01

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2    -0.76450D-03   0.11958D+00  -0.66153D-03   0.14560D-01  -0.26936D-02  -0.17748D-01
Attitude, Rate, Accelerom Sens       2    -0.76450D-03   0.11958D+00  -0.66153D-03   0.14560D-01  -0.26936D-02  -0.17748D-01
Attitude, Rate, Accelerom Sens       2    -0.76450D-03   0.11958D+00  -0.66153D-03   0.14560D-01  -0.26936D-02  -0.17748D-01
Attitude, Rate, Accelerom Sens       2    -0.76450D-03   0.11958D+00  -0.66153D-03   0.14560D-01  -0.26936D-02  -0.17748D-01
Attitude, Rate, Accelerom Sens       2    -0.76450D-03   0.11958D+00  -0.66153D-03   0.14560D-01  -0.26936D-02  -0.17748D-01
Attitude, Rate, Accelerom Sens       2    -0.76450D-03   0.11958D+00  -0.66153D-03   0.14560D-01  -0.26936D-02  -0.17748D-01
Pointing Antena                      1     0.58314D-03  -0.28376D-01  -0.11245D-01  -0.35664D-02   0.88993D-03  -0.92002D-02
Pointing Antena                      1     0.58314D-03  -0.28376D-01  -0.11245D-01  -0.35664D-02   0.88993D-03  -0.92002D-02
Pointing Antena                      1     0.58314D-03  -0.28376D-01  -0.11245D-01  -0.35664D-02   0.88993D-03  -0.92002D-02

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2    -0.76450D-03   0.11958D+00  -0.66153D-03
Attitude, Rate, Accelerom Sens       2    -0.76450D-03   0.11958D+00  -0.66153D-03
Attitude, Rate, Accelerom Sens       2    -0.76450D-03   0.11958D+00  -0.66153D-03
Solar Array Hinge                    4     0.60751D-01   0.27896D-02  -0.35467D-01
Solar Array Hinge                    4     0.60751D-01   0.27896D-02  -0.35467D-01
Solar Array Hinge                    4     0.60751D-01   0.27896D-02  -0.35467D-01

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5     0.94306D-02   0.11050D+00  -0.11248D-01  -0.67235D-01  -0.85441D-02  -0.22049D+00

MODE# 24/ 30, Frequency (rad/sec), Damping (zeta), Generalized Mass=    56.730       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6    -0.13263D-01  -0.32130D-01   0.62756D-01   0.99328D-02  -0.13332D-01   0.21346D-01
Control Moment Gyros (CMG) Loc       6    -0.13263D-01  -0.32130D-01   0.62756D-01   0.99328D-02  -0.13332D-01   0.21346D-01
Control Moment Gyros (CMG) Loc       6    -0.13263D-01  -0.32130D-01   0.62756D-01   0.99328D-02  -0.13332D-01   0.21346D-01
Control Moment Gyros (CMG) Loc       6    -0.13263D-01  -0.32130D-01   0.62756D-01   0.99328D-02  -0.13332D-01   0.21346D-01

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2     0.65740D-02  -0.21027D+00  -0.14221D-02   0.99328D-02  -0.13332D-01   0.21346D-01
Attitude, Rate, Accelerom Sens       2     0.65740D-02  -0.21027D+00  -0.14221D-02   0.99328D-02  -0.13332D-01   0.21346D-01
Attitude, Rate, Accelerom Sens       2     0.65740D-02  -0.21027D+00  -0.14221D-02   0.99328D-02  -0.13332D-01   0.21346D-01
Attitude, Rate, Accelerom Sens       2     0.65740D-02  -0.21027D+00  -0.14221D-02   0.99328D-02  -0.13332D-01   0.21346D-01
Attitude, Rate, Accelerom Sens       2     0.65740D-02  -0.21027D+00  -0.14221D-02   0.99328D-02  -0.13332D-01   0.21346D-01
Attitude, Rate, Accelerom Sens       2     0.65740D-02  -0.21027D+00  -0.14221D-02   0.99328D-02  -0.13332D-01   0.21346D-01
Pointing Antena                      1    -0.85703D-02   0.19747D+00  -0.33472D-01   0.31205D-01   0.49180D-02   0.13493D-01
Pointing Antena                      1    -0.85703D-02   0.19747D+00  -0.33472D-01   0.31205D-01   0.49180D-02   0.13493D-01
Pointing Antena                      1    -0.85703D-02   0.19747D+00  -0.33472D-01   0.31205D-01   0.49180D-02   0.13493D-01

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2     0.65740D-02  -0.21027D+00  -0.14221D-02
Attitude, Rate, Accelerom Sens       2     0.65740D-02  -0.21027D+00  -0.14221D-02
Attitude, Rate, Accelerom Sens       2     0.65740D-02  -0.21027D+00  -0.14221D-02
Solar Array Hinge                    4    -0.30858D-01   0.76540D-02   0.24227D-01
Solar Array Hinge                    4    -0.30858D-01   0.76540D-02   0.24227D-01
Solar Array Hinge                    4    -0.30858D-01   0.76540D-02   0.24227D-01

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5    -0.29346D-01  -0.34917D-01   0.93497D-01  -0.13902D+00  -0.23664D-01  -0.46618D+00

MODE# 25/ 31, Frequency (rad/sec), Damping (zeta), Generalized Mass=    59.243       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6    -0.38240D-02   0.10925D-01   0.27478D-01   0.23705D-02  -0.80977D-02   0.14855D-02
Control Moment Gyros (CMG) Loc       6    -0.38240D-02   0.10925D-01   0.27478D-01   0.23705D-02  -0.80977D-02   0.14855D-02
Control Moment Gyros (CMG) Loc       6    -0.38240D-02   0.10925D-01   0.27478D-01   0.23705D-02  -0.80977D-02   0.14855D-02
Control Moment Gyros (CMG) Loc       6    -0.38240D-02   0.10925D-01   0.27478D-01   0.23705D-02  -0.80977D-02   0.14855D-02

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2     0.77333D-02  -0.20604D-01  -0.12575D-02   0.23705D-02  -0.80977D-02   0.14855D-02
Attitude, Rate, Accelerom Sens       2     0.77333D-02  -0.20604D-01  -0.12575D-02   0.23705D-02  -0.80977D-02   0.14855D-02
Attitude, Rate, Accelerom Sens       2     0.77333D-02  -0.20604D-01  -0.12575D-02   0.23705D-02  -0.80977D-02   0.14855D-02
Attitude, Rate, Accelerom Sens       2     0.77333D-02  -0.20604D-01  -0.12575D-02   0.23705D-02  -0.80977D-02   0.14855D-02
Attitude, Rate, Accelerom Sens       2     0.77333D-02  -0.20604D-01  -0.12575D-02   0.23705D-02  -0.80977D-02   0.14855D-02
Attitude, Rate, Accelerom Sens       2     0.77333D-02  -0.20604D-01  -0.12575D-02   0.23705D-02  -0.80977D-02   0.14855D-02
Pointing Antena                      1    -0.54409D-02   0.57338D-02  -0.37883D-01  -0.79704D-03   0.39049D-02   0.47730D-03
Pointing Antena                      1    -0.54409D-02   0.57338D-02  -0.37883D-01  -0.79704D-03   0.39049D-02   0.47730D-03
Pointing Antena                      1    -0.54409D-02   0.57338D-02  -0.37883D-01  -0.79704D-03   0.39049D-02   0.47730D-03

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2     0.77333D-02  -0.20604D-01  -0.12575D-02
Attitude, Rate, Accelerom Sens       2     0.77333D-02  -0.20604D-01  -0.12575D-02
Attitude, Rate, Accelerom Sens       2     0.77333D-02  -0.20604D-01  -0.12575D-02
Solar Array Hinge                    4     0.11204D-01   0.44624D-02   0.37792D-02
Solar Array Hinge                    4     0.11204D-01   0.44624D-02   0.37792D-02
Solar Array Hinge                    4     0.11204D-01   0.44624D-02   0.37792D-02

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5    -0.78857D-02   0.14335D-01   0.30547D-01  -0.87329D+00  -0.62364D-01   0.24685D+01

MODE# 26/ 32, Frequency (rad/sec), Damping (zeta), Generalized Mass=    60.962       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6    -0.38141D-01  -0.35846D-02   0.16480D+00  -0.96784D-02  -0.53246D-01  -0.61271D-02
Control Moment Gyros (CMG) Loc       6    -0.38141D-01  -0.35846D-02   0.16480D+00  -0.96784D-02  -0.53246D-01  -0.61271D-02
Control Moment Gyros (CMG) Loc       6    -0.38141D-01  -0.35846D-02   0.16480D+00  -0.96784D-02  -0.53246D-01  -0.61271D-02
Control Moment Gyros (CMG) Loc       6    -0.38141D-01  -0.35846D-02   0.16480D+00  -0.96784D-02  -0.53246D-01  -0.61271D-02

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2     0.88860D-01   0.92183D-01  -0.16349D-01  -0.96784D-02  -0.53246D-01  -0.61271D-02
Attitude, Rate, Accelerom Sens       2     0.88860D-01   0.92183D-01  -0.16349D-01  -0.96784D-02  -0.53246D-01  -0.61271D-02
Attitude, Rate, Accelerom Sens       2     0.88860D-01   0.92183D-01  -0.16349D-01  -0.96784D-02  -0.53246D-01  -0.61271D-02
Attitude, Rate, Accelerom Sens       2     0.88860D-01   0.92183D-01  -0.16349D-01  -0.96784D-02  -0.53246D-01  -0.61271D-02
Attitude, Rate, Accelerom Sens       2     0.88860D-01   0.92183D-01  -0.16349D-01  -0.96784D-02  -0.53246D-01  -0.61271D-02
Attitude, Rate, Accelerom Sens       2     0.88860D-01   0.92183D-01  -0.16349D-01  -0.96784D-02  -0.53246D-01  -0.61271D-02
Pointing Antena                      1    -0.49428D-01  -0.55587D-01  -0.40554D+00  -0.13301D-01   0.35270D-01  -0.29730D-02
Pointing Antena                      1    -0.49428D-01  -0.55587D-01  -0.40554D+00  -0.13301D-01   0.35270D-01  -0.29730D-02
Pointing Antena                      1    -0.49428D-01  -0.55587D-01  -0.40554D+00  -0.13301D-01   0.35270D-01  -0.29730D-02

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2     0.88860D-01   0.92183D-01  -0.16349D-01
Attitude, Rate, Accelerom Sens       2     0.88860D-01   0.92183D-01  -0.16349D-01
Attitude, Rate, Accelerom Sens       2     0.88860D-01   0.92183D-01  -0.16349D-01
Solar Array Hinge                    4     0.56553D-01   0.50605D-01   0.19658D-01
Solar Array Hinge                    4     0.56553D-01   0.50605D-01   0.19658D-01
Solar Array Hinge                    4     0.56553D-01   0.50605D-01   0.19658D-01

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5    -0.41074D-01  -0.85316D-02   0.14569D+00   0.14894D+00  -0.19132D+00  -0.22981D+00

MODE# 27/ 33, Frequency (rad/sec), Damping (zeta), Generalized Mass=    63.439       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6    -0.17194D-02   0.36941D-01   0.13102D-01   0.48478D-02   0.25183D-01  -0.15248D-02
Control Moment Gyros (CMG) Loc       6    -0.17194D-02   0.36941D-01   0.13102D-01   0.48478D-02   0.25183D-01  -0.15248D-02
Control Moment Gyros (CMG) Loc       6    -0.17194D-02   0.36941D-01   0.13102D-01   0.48478D-02   0.25183D-01  -0.15248D-02
Control Moment Gyros (CMG) Loc       6    -0.17194D-02   0.36941D-01   0.13102D-01   0.48478D-02   0.25183D-01  -0.15248D-02

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2     0.32807D-01   0.20966D-01  -0.48805D-02   0.48478D-02   0.25183D-01  -0.15248D-02
Attitude, Rate, Accelerom Sens       2     0.32807D-01   0.20966D-01  -0.48805D-02   0.48478D-02   0.25183D-01  -0.15248D-02
Attitude, Rate, Accelerom Sens       2     0.32807D-01   0.20966D-01  -0.48805D-02   0.48478D-02   0.25183D-01  -0.15248D-02
Attitude, Rate, Accelerom Sens       2     0.32807D-01   0.20966D-01  -0.48805D-02   0.48478D-02   0.25183D-01  -0.15248D-02
Attitude, Rate, Accelerom Sens       2     0.32807D-01   0.20966D-01  -0.48805D-02   0.48478D-02   0.25183D-01  -0.15248D-02
Attitude, Rate, Accelerom Sens       2     0.32807D-01   0.20966D-01  -0.48805D-02   0.48478D-02   0.25183D-01  -0.15248D-02
Pointing Antena                      1    -0.41136D-02  -0.30335D-01  -0.46052D-01  -0.35537D-03   0.36052D-02  -0.40141D-02
Pointing Antena                      1    -0.41136D-02  -0.30335D-01  -0.46052D-01  -0.35537D-03   0.36052D-02  -0.40141D-02
Pointing Antena                      1    -0.41136D-02  -0.30335D-01  -0.46052D-01  -0.35537D-03   0.36052D-02  -0.40141D-02

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2     0.32807D-01   0.20966D-01  -0.48805D-02
Attitude, Rate, Accelerom Sens       2     0.32807D-01   0.20966D-01  -0.48805D-02
Attitude, Rate, Accelerom Sens       2     0.32807D-01   0.20966D-01  -0.48805D-02
Solar Array Hinge                    4    -0.30801D+00  -0.26367D+00  -0.45888D+00
Solar Array Hinge                    4    -0.30801D+00  -0.26367D+00  -0.45888D+00
Solar Array Hinge                    4    -0.30801D+00  -0.26367D+00  -0.45888D+00

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5     0.45867D-03   0.30879D-01   0.13818D-01  -0.11505D-01  -0.22464D-01   0.17384D-01

MODE# 28/ 34, Frequency (rad/sec), Damping (zeta), Generalized Mass=    64.288       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6    -0.41456D-02   0.17657D-01  -0.57403D-03   0.10431D-02   0.74362D-02  -0.54398D-03
Control Moment Gyros (CMG) Loc       6    -0.41456D-02   0.17657D-01  -0.57403D-03   0.10431D-02   0.74362D-02  -0.54398D-03
Control Moment Gyros (CMG) Loc       6    -0.41456D-02   0.17657D-01  -0.57403D-03   0.10431D-02   0.74362D-02  -0.54398D-03
Control Moment Gyros (CMG) Loc       6    -0.41456D-02   0.17657D-01  -0.57403D-03   0.10431D-02   0.74362D-02  -0.54398D-03

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2    -0.49073D-03   0.78023D-02  -0.12848D-02   0.10431D-02   0.74362D-02  -0.54398D-03
Attitude, Rate, Accelerom Sens       2    -0.49073D-03   0.78023D-02  -0.12848D-02   0.10431D-02   0.74362D-02  -0.54398D-03
Attitude, Rate, Accelerom Sens       2    -0.49073D-03   0.78023D-02  -0.12848D-02   0.10431D-02   0.74362D-02  -0.54398D-03
Attitude, Rate, Accelerom Sens       2    -0.49073D-03   0.78023D-02  -0.12848D-02   0.10431D-02   0.74362D-02  -0.54398D-03
Attitude, Rate, Accelerom Sens       2    -0.49073D-03   0.78023D-02  -0.12848D-02   0.10431D-02   0.74362D-02  -0.54398D-03
Attitude, Rate, Accelerom Sens       2    -0.49073D-03   0.78023D-02  -0.12848D-02   0.10431D-02   0.74362D-02  -0.54398D-03
Pointing Antena                      1    -0.46669D-02  -0.12197D-01   0.25558D-03   0.81860D-03  -0.85252D-04  -0.17945D-02
Pointing Antena                      1    -0.46669D-02  -0.12197D-01   0.25558D-03   0.81860D-03  -0.85252D-04  -0.17945D-02
Pointing Antena                      1    -0.46669D-02  -0.12197D-01   0.25558D-03   0.81860D-03  -0.85252D-04  -0.17945D-02

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2    -0.49073D-03   0.78023D-02  -0.12848D-02
Attitude, Rate, Accelerom Sens       2    -0.49073D-03   0.78023D-02  -0.12848D-02
Attitude, Rate, Accelerom Sens       2    -0.49073D-03   0.78023D-02  -0.12848D-02
Solar Array Hinge                    4    -0.98408D-01   0.95580D+00  -0.67306D-01
Solar Array Hinge                    4    -0.98408D-01   0.95580D+00  -0.67306D-01
Solar Array Hinge                    4    -0.98408D-01   0.95580D+00  -0.67306D-01

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5    -0.25511D-02   0.15769D-01  -0.27077D-03  -0.94966D-02  -0.11238D-01   0.13084D-01

MODE# 29/ 35, Frequency (rad/sec), Damping (zeta), Generalized Mass=    67.674       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6     0.56167D-02  -0.18997D-01   0.14524D+00  -0.48973D-03  -0.10819D-01  -0.10172D-02
Control Moment Gyros (CMG) Loc       6     0.56167D-02  -0.18997D-01   0.14524D+00  -0.48973D-03  -0.10819D-01  -0.10172D-02
Control Moment Gyros (CMG) Loc       6     0.56167D-02  -0.18997D-01   0.14524D+00  -0.48973D-03  -0.10819D-01  -0.10172D-02
Control Moment Gyros (CMG) Loc       6     0.56167D-02  -0.18997D-01   0.14524D+00  -0.48973D-03  -0.10819D-01  -0.10172D-02

                              Node ID#     Modal Data at the  9 Gyros ...
Attitude, Rate, Accelerom Sens       2     0.37666D-01   0.22513D-01  -0.61804D-02  -0.48973D-03  -0.10819D-01  -0.10172D-02
Attitude, Rate, Accelerom Sens       2     0.37666D-01   0.22513D-01  -0.61804D-02  -0.48973D-03  -0.10819D-01  -0.10172D-02
Attitude, Rate, Accelerom Sens       2     0.37666D-01   0.22513D-01  -0.61804D-02  -0.48973D-03  -0.10819D-01  -0.10172D-02
Attitude, Rate, Accelerom Sens       2     0.37666D-01   0.22513D-01  -0.61804D-02  -0.48973D-03  -0.10819D-01  -0.10172D-02
Attitude, Rate, Accelerom Sens       2     0.37666D-01   0.22513D-01  -0.61804D-02  -0.48973D-03  -0.10819D-01  -0.10172D-02
Attitude, Rate, Accelerom Sens       2     0.37666D-01   0.22513D-01  -0.61804D-02  -0.48973D-03  -0.10819D-01  -0.10172D-02
Pointing Antena                      1     0.31400D-02   0.48402D-01  -0.15526D+00   0.13639D-02   0.17869D-01   0.39890D-02
Pointing Antena                      1     0.31400D-02   0.48402D-01  -0.15526D+00   0.13639D-02   0.17869D-01   0.39890D-02
Pointing Antena                      1     0.31400D-02   0.48402D-01  -0.15526D+00   0.13639D-02   0.17869D-01   0.39890D-02

                              Node ID#     Modal Data at the  6 Accelerometers, along (x,y,z)...
Attitude, Rate, Accelerom Sens       2     0.37666D-01   0.22513D-01  -0.61804D-02
Attitude, Rate, Accelerom Sens       2     0.37666D-01   0.22513D-01  -0.61804D-02
Attitude, Rate, Accelerom Sens       2     0.37666D-01   0.22513D-01  -0.61804D-02
Solar Array Hinge                    4    -0.31498D-03  -0.22651D-01  -0.19901D-01
Solar Array Hinge                    4    -0.31498D-03  -0.22651D-01  -0.19901D-01
Solar Array Hinge                    4    -0.31498D-03  -0.22651D-01  -0.19901D-01

                              Node ID#     Modal Data at the Disturbance Point 
Reboost Engine Thruster 110 (l       5     0.10859D-01   0.21918D-02   0.10192D+00  -0.16525D-01  -0.96872D-02  -0.44964D-01

MODE# 30/ 36, Frequency (rad/sec), Damping (zeta), Generalized Mass=    67.845       0.30000E-02    12.000    
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  4 Single Gimbal GMGs...
Control Moment Gyros (CMG) Loc       6     0.88304D-02  -0.50752D-02   0.35018D-01  -0.11531D-01  -0.47341D-02  -0.35098D-02
