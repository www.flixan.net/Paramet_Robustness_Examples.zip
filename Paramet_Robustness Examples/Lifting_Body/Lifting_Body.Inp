BATCH MODE INSTRUCTIONS ...............                                                             
Batch Set for Creating Glider Design Models                                                                                             
! This batch creates flight vehicle models with 35 structured uncertainties
! for robustness analysis
!
Flight Vehicle   : Lifting-Body at Mach 0.8, Alpha 20, Qbar 400, h=3000 (ft)                                                                                                                                                             
Flight Vehicle   : Lifting-Body at Mach 0.8, Alpha 20, Qbar 400, h=3000 (ft) with 35 Uncertainties                                                                                                                                                             
To Matlab Format : Lifting-Body at Mach 0.8, Alpha 20, Qbar 400, h=3000 (ft)                                                                                                                                                             
To Matlab Format : Lifting-Body at Mach 0.8, Alpha 20, Qbar 400, h=3000 (ft) with 35 Uncertainties                                                                                                                                                             
------------------------------------------------------------------------------------------------------------------------                                                                                                    
FLIGHT VEHICLE INPUT DATA ......                                                                    
Lifting-Body at Mach 0.8, Alpha 20, Qbar 400, h=3000 (ft)
! The following Lifting-Body vehicle has 6 control surfaces and 3 RCS jets
Body Axes Output,Attitude=Euler Angles,Without GAFD, No Turn Coordination                                                                                                                                                   
                                                                                                                                                                                                                            
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :  550.0        32.17        0.20896E+08                                                                                           
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :  7000.0       30000.0      33000.0      0.0000       400.00       0.0000                                                         
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        : -28.32        0.0          0.0                                                                                                 
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :  0.8          700.0        400.00       3000.0                                                                                   
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         : -98.0         0.0         -50.00       -60.0                                                                                    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  20.0         0.0         -10.0         0.0000                                                                                   
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   : -0.0          20.0         0.0000       0.0000       0.0000       0.0000                                                         
Wind Gust Velocity, Wind Direction to Vehicle Defined by Azimuth and Elevat Angles (deg) :  Gust        -135.0        90.0     
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :  300.0        30.0         15.0                                                                                                
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} : -27.9         0.0          0.0          0.0000                                                                                   
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}: -0.0021,  -0.0045,   0.00035, 0.0,    0.0,    -0.2,    0.0                                                                         
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  0.0,     -0.014,    1.7,    0.0,   0.00838,   0.0,    0.0                                              
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -0.7,     -0.03,    -5.0,    0.0,     0.0,     0.0,   -0.0001                                                                     
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:  0.0,     -0.01,     0.0,   -0.3,     0.4,     0.0                                                       
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}: -0.012,   -0.0006,   0.0,    0.0,    -0.5,    0.00003, 0.0                                                                         
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:  0.0,      0.0033,   0.0,    0.184,  -0.49,    0.0                                                                                 

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  4   NO TWD                                                                                                                      

Control Surface No:  1                                                                     Elevon                                                                                                                        
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg):  0.0           30.000     -30.000       +0.0000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.00         0.0          0.0           0.0                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  0.0         -0.0         -0.0                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.0011       0.0         -0.003         0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0         -0.0015       0.0           0.0000       0.0000       0.0000                                                        
Control Surface No:  2                                                                     Aileron                                                                                                                       
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_cs,lamda_cs (deg):  0.0           30.000     -30.000        0.0000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :  0.0          0.0          0.00          0.0000                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  0.0          0.0         -0.0                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.0          0.0001       0.0           0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0016       0.0         -0.00002       0.0000       0.0000       0.0000                                                        
Control Surface No:  3                                                                     Rudder-1                                                                                                                      
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg):  0.0           30.000     -30.000       +0.0000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :  0.0          0.0          0.0           0.0                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  0.0          0.0          0.0                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.0          0.004        0.0           0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0005       0.0         -0.002         0.0000       0.0000       0.0000                                                        
Control Surface No:  4                                                                     Rudder-2                                             
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg):  0.0          30.000      -30.000       +0.0000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :  0.0          0.0          0.0           0.0                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  0.0         -0.0         -0.0                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.0          0.006        0.0           0.0          0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.004        0.0          0.005         0.0          0.0000       0.0000                                                        
                                                                                                                                                                                                                            
Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  3                             
                                                                                                                                                                                                                            
RCS Jet No:  1                      (Gimbaling  Throttling   Single_Gimbal)              : Jet #1         Throttling                                                                                                      
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.0          30.0                                                                                                            
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):   0.0         -90.0        0.0           0.0                                                                                     
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00         0.0         0.0
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   4.5          0.0         0.0                                                                                                   
RCS Jet No:  2                      (Gimbaling  Throttling   Single_Gimbal)              : Jet #2         Throttling                                                                                                      
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.0          30.0                                                                                                            
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -90.0          00.0        0.0           0.0                                                                                     
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00         0.0         0.0
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   4.2         -4.0         0.0                                                                                                   
RCS Jet No:  3                      (Gimbaling  Throttling   Single_Gimbal)              : Jet #3         Throttling                                                                                                      
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.0          30.0                                                                                                            
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -90.0          00.0        0.0           0.0                                                                                     
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00         0.0         0.0
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   4.2          4.0         0.0                                                                                                   
                                                                                                                                                                                                                                                                                                                                                                                                                                                        
Number of Gyros, (Attitude and Rate)                                                     :  0                                                                                                                               
                                                                                                                                                                                                                            
Number of Accelerometers, (x,y,z)                                                        :  0                                                                                                                               
                                                                                                                                                                                                                            
Number of Vane Sensors, (Alpha or Beta)                                                  :  0                                                                                                                               
                                                                                                                                                                                                                            
Number of Slosh Modes                                                                    :  0                                                                                                                               
                                                                                                                                                                                                                            
Number of Bending Modes                                                                  :  0                                                                                                                               
                                                                                                                                                                                                                            
--------------------------------------------------------------------------------------------------------------------------------------                                                                                      
FLIGHT VEHICLE INPUT DATA ......                                                                    
Lifting-Body at Mach 0.8, Alpha 20, Qbar 400, h=3000 (ft) with 35 Uncertainties
! The following Lifting-Body vehicle has 6 control surfaces and 3 RCS jets
Body Axes Output,Attitude=Euler Angles,Without GAFD, No Turn Coordination                                                                                                                                                   
                                                                                                                                                                                                                            
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :  550.0        32.17        0.20896E+08                                                                                           
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :  7000.0       30000.0      33000.0      0.0000       400.00       0.0000                                                         
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        : -28.32        0.0          0.0                                                                                                 
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :  0.8          700.0        400.00       3000.0                                                                                   
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         : -98.0         0.0         -50.00       -60.0                                                                                    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  20.0         0.0         -10.0         0.0000                                                                                   
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   : -0.0          20.0         0.0000       0.0000       0.0000       0.0000                                                         
Wind Gust Vel wrt Vehi (Azim & Elev) angles (deg), or Force(lb), Torque(ft-lb), locat:xyz:  Gust        -135.0        90.0                                                                                                  
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :  300.0        30.0         15.0                                                                                                
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} : -27.9         0.0          0.0          0.0000                                                                                   
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}: -0.0021,  -0.0045,   0.00035, 0.0,    0.0,    -0.2,    0.0                                                                         
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  0.0,     -0.014,    1.7,    0.0,   0.00838,   0.0,    0.0                                              
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -0.7,     -0.03,    -5.0,    0.0,     0.0,     0.0,   -0.0001                                                                     
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:  0.0,     -0.01,     0.0,   -0.3,     0.4,     0.0                                                       
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}: -0.012,   -0.0006,   0.0,    0.0,    -0.5,    0.00003, 0.0                                                                         
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:  0.0,      0.0033,   0.0,    0.184,  -0.49,    0.0                                                                                 

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  4   NO TWD                                                                                                                      

Control Surface No:  1                                                                     Elevon                                                                                                                        
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg):  0.0           30.000     -30.000       +0.0000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           : -0.00         0.0          0.0           0.0                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  0.0         -0.0         -0.0                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.0011       0.0         -0.003         0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0         -0.0015       0.0           0.0000       0.0000       0.0000                                                        
Control Surface No:  2                                                                     Aileron                                                                                                                       
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_cs,lamda_cs (deg):  0.0           30.000     -30.000        0.0000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :  0.0          0.0          0.00          0.0000                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  0.0          0.0         -0.0                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.0          0.0001       0.0           0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0016       0.0         -0.00002       0.0000       0.0000       0.0000                                                        
Control Surface No:  3                                                                     Rudder-1                                                                                                                      
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg):  0.0           30.000     -30.000       +0.0000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :  0.0          0.0          0.0           0.0                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  0.0          0.0          0.0                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.0          0.004        0.0           0.0000       0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0005       0.0         -0.002         0.0000       0.0000       0.0000                                                        
Control Surface No:  4                                                                     Rudder-2                                             
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: phi_h, lamda_h  (deg):  0.0          30.000      -30.000       +0.0000       0.000                                                                      
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0                                                                     
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :  0.0          0.0          0.0           0.0                                                                                  
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  0.0         -0.0         -0.0                                                                                                
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.0          0.006        0.0           0.0          0.0000       0.0000                                                        
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.004        0.0          0.005         0.0          0.0000       0.0000                                                        
                                                                                                                                                                                                                            
Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  3                             
                                                                                                                                                                                                                            
RCS Jet No:  1                      (Gimbaling  Throttling   Single_Gimbal)              : Jet #1         Throttling                                                                                                      
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.0          30.0                                                                                                            
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):   0.0         -90.0        0.0           0.0                                                                                     
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00         0.0         0.0
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   4.5          0.0         0.0                                                                                                   
RCS Jet No:  2                      (Gimbaling  Throttling   Single_Gimbal)              : Jet #2         Throttling                                                                                                      
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.0          30.0                                                                                                            
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -90.0          00.0        0.0           0.0                                                                                     
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00         0.0         0.0
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   4.2         -4.0         0.0                                                                                                   
RCS Jet No:  3                      (Gimbaling  Throttling   Single_Gimbal)              : Jet #3         Throttling                                                                                                      
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :   0.0          30.0                                                                                                            
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -90.0          00.0        0.0           0.0                                                                                     
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):   0.00         0.0         0.0
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :   4.2          4.0         0.0                                                                                                   
                                                                                                                                                                                                                                                                                                                                                                                                                                                        
Number of Gyros, (Attitude and Rate)                                                     :  0                                                                                                                               
                                                                                                                                                                                                                            
Number of Accelerometers, (x,y,z)                                                        :  0                                                                                                                               
                                                                                                                                                                                                                            
Number of Vane Sensors, (Alpha or Beta)                                                  :  0                                                                                                                               
                                                                                                                                                                                                                            
Number of Slosh Modes                                                                    :  0                                                                                                                               

Parameter Uncertainties Data
Uncertainties at Mach=0.8, Alpha=20
                                                                                                                                                                                                                            
Number of Bending Modes                                                                  :  0                                                                                                                                                                                                          
-------------------------------------------------------------------------------------------------------------------------------------------------------                                                                  
UNCERTAIN PARAMETER VARIATIONS FROM NOMINAL ......                                                                    
Uncertainties at Mach=0.8, Alpha=20
! The following data are not actual vehicle parameters but they represent uncertainties
! of the corresponding parameters for the vehicle above. The title above these comments                                                                                
! defines the flight condition where they apply. The uncertainty values represent a +ve 
! or -ve additive variation above or below the nominal values shown in the set above.
                                                                                                                                                                                                                            
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :  0.0          0.0          0.0                                                                                           
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :  200.0       1000.0       1000.0        0.0   0.0    0.0                                                       
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  0.5          0.5          0.5                                                                                                 
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :  0.0          0.0          0.0          0.0                                                                                  
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :  0.0          0.0          0.0          0.0                                                                                    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  2.0          2.0          0.0          0.0                                                                        
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   : -0.0          0.0          0.0          0.0   0.0    0.0                                                       
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.005, -0.001,    0.0,   0.0,     0.0,     0.0,    0.0                                                                         
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  0.0,   -0.002,    0.0,   0.0,     0.0,     0.0,    0.0                                                                         
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:  0.02,  -0.003,    1.0,   0.0,     0.0,     0.0,    0.0                                            
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:  0.0,   -0.002,    0.0,   0.1,     0.1,     0.0                                                                                 
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:  0.006, -0.001,    0.0,   0.0,     0.2,     0.0,    0.0                                                                         
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:  0.0,    0.001,    0.0,   0.1,     0.1,     0.0                                                                                 
                                                                                                                                                                                                                            
Number of Control Surfaces, (Variations from Nominal Aero Parameters)                    :  4                                                                                                    
                                                                                                                                                                                                                            
Control Surface No:  1                                                                     Elevon                                          
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0       
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}: -0.0002       0.0         -0.0005        0.0          0.0          0.0  
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0         -0.0002       0.0           0.0          0.0          0.0    
Control Surface No:  2                                                                     Aileron
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0       
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.0          0.0005       0.0           0.0          0.0          0.0  
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.00024      0.0          0.00013       0.0          0.0          0.0    
Control Surface No:  3                                                                     Rudder-1                                                                                                       
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0       
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.0          0.00043      0.0           0.0          0.0          0.0  
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.0002       0.0          0.0002        0.0          0.0          0.0    
Control Surface No:  4                                                                     Rudder-2                                                                                     
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :  0.0          0.0          0.0           0.0          0.0       
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.0          0.0003       0.0           0.0          0.0          0.0  
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:  0.00025      0.0          0.0003        0.0          0.0          0.0    

Number of Thruster Engines, (Variations from Nominal Parameters)                         :  3                                                           

TVC Engine No:  1                                                                        : Jet #1      
Engine Thrust Additive Variation,  (lb)                                                  :  0.0     
Engine Mounting Angles Variations from Nominal Angles (Dyn,Dzn) (deg)                    :  0.0        0.0       
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm: engine CG to gimbal (ft):  0.0        0.0     0.0           
TVC Engine No:  2                                                                        : Jet #2   
Engine Thrust Additive Variation,  (lb)                                                  :  0.0     
Engine Mounting Angles Variations from Nominal Angles (Dyn,Dzn) (deg)                    :  0.0        0.0       
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  0.0        0.0     0.0           
TVC Engine No:  3                                                                        : Jet #3      
Engine Thrust Additive Variation,  (lb)                                                  :  0.0     
Engine Mounting Angles Variations from Nominal Angles (Dyn,Dzn) (deg)                    : -0.0       -0.0       
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  0.0        0.0     0.0           
                                                                                                                                                                                                                                                                                                                                                                                                                           
Number of Gyros, (Attitude and Rate)                                                     :  0                                                                                                                               
                                                                                                                                                                                                                            
Number of Accelerometers, (x,y,z)                                                        :  0                                                                                                                               
                                                                                                                                                                                                                            
Number of Vane Sensors, (Alpha or Beta)                                                  :  0                                                                                                                               
                                                                                                                                                                                                                            
Number of Slosh Modes                                                                    :  0                                                                                                                               
                                                                      
----------------------------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (TITLE, SYSTEM/MATRIX, M-FILENAME)                           
Lifting-Body at Mach 0.8, Alpha 20, Qbar 400, h=3000 (ft)                                                                                                          
System                                                                                                                                                                                                                      
Vehicle_Nom.m                                                                                                                                                                                                           
----------------------------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (TITLE, SYSTEM/MATRIX, M-FILENAME)                           
Lifting-Body at Mach 0.8, Alpha 20, Qbar 400, h=3000 (ft) with 35 Uncertainties                                                                                                          
System                                                                                                                                                                                                                      
Vehicle_35Unc.m                                                                                                                                                                                                           
----------------------------------------------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
